# IAR project nvm_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/boards/stk600/rc064x; ../../../../../services/spi/xmega_spi; ../../../../../services/clock; ../../../../../services/gpio; ../../../../../services/spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../components/memory/data_flash/at45dbx; ../../../../../../xmega/utils; ../../../../../../xmega/drivers/spi; ..; ../../../../../services/ioport; ../../..; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/spi
    ../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/boards/stk600/rc064x
    ../../../../../../xmega/boards/stk600/rc064x/: init.c stk600_rc064x.h led.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group common/services/spi
    ../../../../../services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/ioport
    ../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/drivers/nvm
    ../../../: common_nvm.h
  group common/drivers/nvm/xmega
    ../../../xmega/: xmega_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/drivers/nvm/example/atxmega256a3u_stk600-rc064x
    ../: conf_nvm.h conf_nvm_example.h conf_clock.h conf_at45dbx.h conf_board.h conf_spi_master.h
  group common/drivers/nvm/example/atxmega256a3u_stk600-rc064x/iar
    ./: asf.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
