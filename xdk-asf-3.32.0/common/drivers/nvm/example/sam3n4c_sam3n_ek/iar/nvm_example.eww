<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\nvm_example_sram.ewp</path>
	</project>
</workspace>
