# IAR project nvm_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3N4C Atmel ATSAM3N4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils; ../../../../../services/clock; ..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pio; ../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../sam/drivers/pmc; ../../../../../../sam/services/flash_efc; ../../..; ../../../../../../sam/boards; ../../../../../../sam/boards/sam3n_ek; ../../../../../utils; ../../../../../services/gpio; ../../../../../services/ioport; ../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nvm_example_flash.bin
  ILINK.IlinkOutputFile: nvm_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/drivers/nvm
    ../../../: common_nvm.h
  group common/drivers/nvm/sam
    ../../../sam/: sam_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/drivers/nvm/example/sam3n4c_sam3n_ek
    ../: conf_clock.h conf_board.h conf_nvm_example.h conf_nvm.h
  group common/drivers/nvm/example/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3n
    ../../../../../services/clock/sam3n/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/gpio
    ../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../boards/: board.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c system_sam3n.h exceptions.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../sam/utils/cmsis/sam3n/include/: sam3n1a.h sam3n00b.h sam3n1b.h sam3n0b.h sam3n4b.h sam3n00a.h sam3n0a.h sam3n1c.h sam3n2a.h sam3n2b.h sam3n0c.h sam3n4a.h sam3n4c.h sam3n2c.h sam3n.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_usart0.h instance_rtc.h instance_adc.h instance_tc1.h instance_twi0.h instance_rtt.h instance_efc.h instance_pioa.h instance_piob.h instance_twi1.h instance_tc0.h instance_wdt.h instance_dacc.h instance_chipid.h instance_usart1.h instance_uart0.h instance_pioc.h instance_spi.h instance_pwm.h instance_rstc.h instance_gpbr.h instance_pmc.h instance_matrix.h instance_supc.h instance_uart1.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../sam/utils/cmsis/sam3n/include/component/: component_rstc.h component_adc.h component_twi.h component_spi.h component_pdc.h component_matrix.h component_pio.h component_efc.h component_dacc.h component_pwm.h component_wdt.h component_gpbr.h component_pmc.h component_rtt.h component_supc.h component_usart.h component_tc.h component_rtc.h component_chipid.h component_uart.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n00b.h pio_sam3n0a.h pio_sam3n0b.h pio_sam3n00a.h pio_sam3n0c.h pio_sam3n2a.h pio_sam3n4b.h pio_sam3n2b.h pio_sam3n1a.h pio_sam3n1c.h pio_sam3n4c.h pio_sam3n2c.h pio_sam3n1b.h pio_sam3n4a.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/sam3n_ek
    ../../../../../../sam/boards/sam3n_ek/: led.c init.c sam3n_ek.h led.h
