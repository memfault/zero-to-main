<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_example.ewp</path>
	</project>
</workspace>
