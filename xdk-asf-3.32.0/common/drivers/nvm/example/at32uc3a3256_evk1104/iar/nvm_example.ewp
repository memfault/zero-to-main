# IAR project nvm_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104; USE_EXTMEM
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/utils; ../../../../../services/clock; ../../../../../services/spi; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../components/memory/data_flash/at45dbx; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards/evk1104; ../../../../../services/ioport; ../../../../../services/spi/uc3_spi; ../../..; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; ../../../../../../avr32/drivers/spi; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104; USE_EXTMEM
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/drivers/nvm
    ../../../: common_nvm.h
  group common/drivers/nvm/uc3
    ../../../uc3/: uc3_nvm.c flash_api.h
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/drivers/nvm/example/at32uc3a3256_evk1104
    ../: conf_clock.h conf_nvm.h conf_at45dbx.h conf_nvm_example.h conf_board.h conf_spi_master.h
  group common/drivers/nvm/example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/services/clock
    ../../../../../services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../services/clock/uc3a3_a4/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/spi
    ../../../../../services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../services/ioport/uc3/: ioport.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/boards/evk1104
    ../../../../../../avr32/boards/evk1104/: led.c init.c evk1104.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
