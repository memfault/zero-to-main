# IAR project nvm_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../sam/boards/sam4s_ek; ../../../../../../sam/utils; ../../../../../services/clock; ..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pio; ../../../../../services/ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/services/flash_efc; ../../..; ../../../../../../sam/boards; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../services/gpio; ../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nvm_example_flash.bin
  ILINK.IlinkOutputFile: nvm_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/drivers/nvm
    ../../../: common_nvm.h
  group common/drivers/nvm/sam
    ../../../sam/: sam_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/drivers/nvm/example/sam4s16c_sam4s_ek
    ../: conf_clock.h conf_board.h conf_nvm_example.h conf_nvm.h
  group common/drivers/nvm/example/sam4s16c_sam4s_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/sam4s
    ../../../../../services/clock/sam4s/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/gpio
    ../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../boards/: board.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../sam/utils/cmsis/sam4s/include/: sam4sa16c.h sam4s.h sam4s8c.h sam4s2a.h sam4s4b.h system_sam4s.h sam4s2b.h sam4s2c.h sam4s4a.h sam4s4c.h sam4sd16c.h sam4s16c.h sam4sd32c.h sam4sd16b.h sam4sa16b.h sam4s8b.h sam4s16b.h sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s8b.h pio_sam4s4b.h pio_sam4s2c.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4sd16c.h pio_sam4s8c.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4sd16b.h pio_sam4sa16b.h pio_sam4s16c.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4s16b.h pio_sam4sd32c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_matrix.h instance_uart0.h instance_pwm.h instance_usart0.h instance_tc0.h instance_supc.h instance_twi0.h instance_crccu.h instance_efc0.h instance_uart1.h instance_gpbr.h instance_hsmci.h instance_spi.h instance_twi1.h instance_piob.h instance_pioc.h instance_efc1.h instance_smc.h instance_ssc.h instance_pioa.h instance_adc.h instance_pmc.h instance_rtc.h instance_rstc.h instance_chipid.h instance_rtt.h instance_cmcc.h instance_wdt.h instance_udp.h instance_dacc.h instance_usart1.h instance_tc1.h instance_acc.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../sam/utils/cmsis/sam4s/include/component/: component_supc.h component_tc.h component_ssc.h component_pmc.h component_usart.h component_spi.h component_smc.h component_dacc.h component_rtc.h component_pdc.h component_udp.h component_chipid.h component_adc.h component_twi.h component_hsmci.h component_crccu.h component_rstc.h component_rtt.h component_gpbr.h component_efc.h component_matrix.h component_acc.h component_uart.h component_cmcc.h component_wdt.h component_pwm.h component_pio.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4s_ek
    ../../../../../../sam/boards/sam4s_ek/: init.c led.c sam4s_ek.h led.h
