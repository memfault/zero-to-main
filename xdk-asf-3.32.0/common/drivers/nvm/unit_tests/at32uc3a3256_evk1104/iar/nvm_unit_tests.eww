<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_unit_tests.ewp</path>
	</project>
</workspace>
