# IAR project nvm_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../xmega/drivers/pmic; ../../../../../services/clock; ../../../../../services/gpio; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../services/ioport; ../../../../../../xmega/drivers/usart; ../../..; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../services/serial/xmega_usart; ../../../../../../xmega/drivers/cpu; ../../../../../services/serial; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c xmega_a3bu_xplained.h led.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/drivers/nvm
    ../../../: common_nvm.h
  group common/drivers/nvm/unit_tests
    ../../: unit_tests.c
  group common/drivers/nvm/unit_tests/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_usart_serial.h conf_test.h conf_nvm.h conf_clock.h conf_board.h
  group common/drivers/nvm/unit_tests/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/drivers/nvm/xmega
    ../../../xmega/: xmega_nvm.c
  group common/services/clock
    ../../../../../services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/serial
    ../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../services/serial/xmega_usart/: usart_serial.h
  group common/services/ioport
    ../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../boards/: board.h
