# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Atmel ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8H__; ARM_MATH_CM3=true; BOARD=SAM3X_EK; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc/device; ../../../../../../../sam/drivers/uotghs; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/boards/sam3x_ek; ../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../sam/utils/cmsis/sam3x/include; ../../..; ../../../../../../services/sleepmgr; ../../../../..; ../../../../../../services/usb/class/cdc; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../services/gpio; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8H__; ARM_MATH_CM3=true; BOARD=SAM3X_EK; UDD_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c stdio_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c conf_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam3x8h_sam3x_ek
    ../: conf_clock.h conf_board.h conf_sleepmgr.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/sam3x
    ../../../../../../services/clock/sam3x/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/usb
    ../../../../../../services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc_desc.h udi.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8c.h sam3x8e.h sam3a4c.h sam3x4c.h sam3x4e.h sam3a8c.h sam3x8h.h sam3xa.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../../sam/utils/cmsis/sam3x/include/component/: component_pwm.h component_rtc.h component_spi.h component_dmac.h component_uotghs.h component_gpbr.h component_pmc.h component_trng.h component_smc.h component_chipid.h component_efc.h component_dacc.h component_emac.h component_hsmci.h component_tc.h component_pdc.h component_uart.h component_rtt.h component_sdramc.h component_rstc.h component_adc.h component_can.h component_supc.h component_pio.h component_usart.h component_wdt.h component_ssc.h component_twi.h component_matrix.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_piob.h instance_tc0.h instance_tc1.h instance_pwm.h instance_trng.h instance_can1.h instance_pmc.h instance_usart2.h instance_wdt.h instance_smc.h instance_usart0.h instance_rtc.h instance_sdramc.h instance_adc.h instance_twi1.h instance_spi1.h instance_can0.h instance_matrix.h instance_emac.h instance_usart3.h instance_efc1.h instance_dacc.h instance_usart1.h instance_pioe.h instance_tc2.h instance_rtt.h instance_spi0.h instance_twi0.h instance_gpbr.h instance_ssc.h instance_supc.h instance_efc0.h instance_pioc.h instance_piof.h instance_dmac.h instance_pioa.h instance_chipid.h instance_piod.h instance_rstc.h instance_uart.h instance_hsmci.h instance_uotghs.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3x8h.h pio_sam3x4c.h pio_sam3x8c.h pio_sam3x4e.h pio_sam3x8e.h pio_sam3a8c.h pio_sam3a4c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/uotghs
    ../../../../../../../sam/drivers/uotghs/: uotghs_device.c uotghs_otg.h uotghs_device.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/boards/sam3x_ek
    ../../../../../../../sam/boards/sam3x_ek/: init.c led.c sam3x_ek.h led.h
