<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\stdio_usb_example_flash.ewp</path>
	</project>
</workspace>
