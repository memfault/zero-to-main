# IAR project stdio_usb_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../services/usb/class/cdc; ../../../../../../services/usb/class/cdc/device; ../../../../../../../avr32/drivers/gpio; ../../../../../../services/clock; ../../../../../../../avr32/drivers/pm; ../..; ../../../../../../boards; ../../../../../../services/usb; ..; ../../../../../../../avr32/boards; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/usb/udc; ../../..; ../../../../../../../avr32/utils; ../../../../../../../avr32/boards/evk1101; ../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr32/drivers/usbb; ../../../../../../services/sleepmgr; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c pm.h sleep.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/usbb
    ../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_otg.h usbb_device.h
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/evk1101
    ../../../../../../../avr32/boards/evk1101/: led.c init.c evk1101.h led.h
  group avr32/utils
    ../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../avr32/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group avr32/utils/header_files
    ../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc.h udc_desc.h udi.h udd.h
  group common/services/clock
    ../../../../../../services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/uc3b0_b1
    ../../../../../../services/clock/uc3b0_b1/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c stdio_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c conf_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/at32uc3b0256_evk1101
    ../: conf_clock.h conf_board.h conf_sleepmgr.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/at32uc3b0256_evk1101/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../boards/: board.h
