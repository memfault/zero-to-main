# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc; ../../../../../../services/usb/class/cdc/device; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../..; ../../../../../../../sam/drivers/matrix; ../../../../../../services/sleepmgr; ../../../../..; ..; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../sam/drivers/udp; ../../../../../../services/gpio; ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s16c.h sam4sd32c.h sam4s2b.h sam4s4b.h system_sam4s.h sam4sd32b.h sam4sd16b.h sam4s16b.h sam4sa16c.h sam4s8b.h sam4sd16c.h sam4s.h sam4s8c.h sam4sa16b.h sam4s4c.h sam4s2a.h sam4s4a.h sam4s2c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_adc.h instance_piob.h instance_matrix.h instance_ssc.h instance_efc0.h instance_chipid.h instance_usart0.h instance_pioa.h instance_acc.h instance_rstc.h instance_hsmci.h instance_gpbr.h instance_udp.h instance_twi0.h instance_efc1.h instance_rtt.h instance_usart1.h instance_supc.h instance_tc0.h instance_pmc.h instance_uart0.h instance_uart1.h instance_smc.h instance_rtc.h instance_pioc.h instance_tc1.h instance_cmcc.h instance_dacc.h instance_pwm.h instance_spi.h instance_crccu.h instance_wdt.h instance_twi1.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_twi.h component_acc.h component_pio.h component_spi.h component_hsmci.h component_rstc.h component_usart.h component_adc.h component_smc.h component_udp.h component_wdt.h component_pwm.h component_cmcc.h component_matrix.h component_efc.h component_supc.h component_gpbr.h component_ssc.h component_pmc.h component_dacc.h component_rtt.h component_crccu.h component_chipid.h component_rtc.h component_uart.h component_pdc.h component_tc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s4b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4s8b.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4sd32c.h pio_sam4sa16b.h pio_sam4sd16b.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s8c.h pio_sam4s16c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: led.c init.c led.h sam4s_xplained.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/matrix
    ../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c stdio_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c conf_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam4s16c_sam4s_xplained
    ../: conf_sleepmgr.h conf_clock.h conf_board.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc_desc.h udi.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam4s
    ../../../../../../services/clock/sam4s/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
