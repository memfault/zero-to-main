<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\stdio_usb_example.ewp</path>
	</project>
</workspace>
