# IAR project stdio_usb_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../services/usb/class/cdc; ../../../../../../services/usb/class/cdc/device; ../../../../../../services/usb/udc; ../../../../../../../xmega/drivers/usb; ../../../../../../services/gpio; ../..; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../xmega/utils; ../../../../../../services/clock; ../../../../../../services/usb; ../../../../..; ../../../../../../../xmega/boards; ../../../../../../../xmega/drivers/nvm; ../../../../../../services/sleepmgr; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/ioport; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/sleep
    ../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../../../xmega/utils/: status_codes.h compiler.h assembler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c stdio_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c conf_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_clock.h conf_board.h conf_sleepmgr.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_avr8.h
  group common/services/usb
    ../../../../../../services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc.h udc_desc.h udi.h udd.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
