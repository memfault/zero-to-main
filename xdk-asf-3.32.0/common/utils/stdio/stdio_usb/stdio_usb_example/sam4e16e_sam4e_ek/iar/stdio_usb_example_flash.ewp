# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc/device; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/fpu; ../../..; ../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../sam/boards; ../../../../../../services/sleepmgr; ../../../../..; ../../../../../../services/usb/class/cdc; ../../../../../../services/clock; ../../../../../../../sam/drivers/matrix; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../sam/drivers/udp; ..; ../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc_desc.h udi.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam4e
    ../../../../../../services/clock/sam4e/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c stdio_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c conf_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam4e16e_sam4e_ek
    ../: conf_clock.h conf_board.h conf_sleepmgr.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e.h sam4e8c.h sam4e16cb.h sam4e8e.h sam4e8cb.h sam4e16c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16c.h sam4e8c.h sam4e8e.h sam4e8cb.h sam4e16cb.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../sam/utils/cmsis/sam4e/include/component/: aes.h pdc.h rtt.h gpbr.h gmac.h pio.h rswdt.h efc.h uart.h tc.h smc.h dmac.h afec.h usart.h wdt.h twi.h hsmci.h pmc.h udp.h supc.h matrix.h rtc.h can.h acc.h rstc.h chipid.h cmcc.h spi.h pwm.h dacc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../sam/utils/cmsis/sam4e/include/instance/: udp.h uart0.h afec1.h pmc.h aes.h afec0.h twi1.h spi.h can0.h piod.h matrix.h piob.h can1.h efc.h chipid.h twi0.h dmac.h rtc.h rswdt.h pwm.h wdt.h tc0.h rtt.h gpbr.h tc2.h gmac.h hsmci.h supc.h tc1.h acc.h rstc.h usart0.h uart1.h cmcc.h smc.h dacc.h pioa.h pioe.h usart1.h pioc.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/matrix
    ../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/boards/sam4e_ek
    ../../../../../../../sam/boards/sam4e_ek/: init.c led.h sam4e_ek.h
