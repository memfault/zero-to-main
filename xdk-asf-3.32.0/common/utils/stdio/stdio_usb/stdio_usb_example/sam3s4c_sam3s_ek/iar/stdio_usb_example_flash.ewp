# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3S4C Atmel ATSAM3S4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK; ARM_MATH_CM3=true; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc/device; ..; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam3s/include; ../../..; ../../../../../../../sam/boards; ../../../../../../services/sleepmgr; ../../../../..; ../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../../../../../services/usb/class/cdc; ../../../../../../../sam/boards/sam3s_ek; ../../../../../../services/clock; ../../../../../../../sam/drivers/matrix; ../../../../../../../sam/utils/preprocessor; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../sam/drivers/udp; ../../../../../../services/gpio; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK; ARM_MATH_CM3=true; UDD_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c stdio_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c conf_usb.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam3s4c_sam3s_ek
    ../: conf_clock.h conf_board.h conf_sleepmgr.h
  group common/utils/stdio/stdio_usb/stdio_usb_example/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c udc_desc.h udi.h udd.h udc.h
  group common/services/sleepmgr
    ../../../../../../services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam3s
    ../../../../../../services/clock/sam3s/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../sam/utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c system_sam3s.h exceptions.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../../../../../sam/utils/cmsis/sam3s/include/: sam3s2a.h sam3s4c.h sam3s2c.h sam3s4b.h sam3s2b.h sam3s1b.h sam3s4a.h sam3s1c.h sam3s.h sam3s1a.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../../../../../sam/utils/cmsis/sam3s/include/component/: component_adc.h component_smc.h component_usart.h component_twi.h component_wdt.h component_rstc.h component_pwm.h component_acc.h component_ssc.h component_rtc.h component_pio.h component_efc.h component_gpbr.h component_spi.h component_uart.h component_pdc.h component_rtt.h component_chipid.h component_udp.h component_dacc.h component_supc.h component_pmc.h component_crccu.h component_tc.h component_matrix.h component_hsmci.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../../../../../sam/utils/cmsis/sam3s/include/instance/: instance_gpbr.h instance_smc.h instance_rtc.h instance_tc0.h instance_efc.h instance_tc1.h instance_rstc.h instance_pwm.h instance_rtt.h instance_udp.h instance_ssc.h instance_usart1.h instance_matrix.h instance_hsmci.h instance_piob.h instance_pmc.h instance_pioa.h instance_twi1.h instance_twi0.h instance_adc.h instance_uart0.h instance_usart0.h instance_dacc.h instance_crccu.h instance_pioc.h instance_wdt.h instance_supc.h instance_acc.h instance_chipid.h instance_uart1.h instance_spi.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../../../../../sam/utils/cmsis/sam3s/include/pio/: pio_sam3s2a.h pio_sam3s1b.h pio_sam3s4c.h pio_sam3s2c.h pio_sam3s4a.h pio_sam3s2b.h pio_sam3s1c.h pio_sam3s4b.h pio_sam3s1a.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/matrix
    ../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/boards/sam3s_ek
    ../../../../../../../sam/boards/sam3s_ek/: init.c led.c sam3s_ek.h led.h
