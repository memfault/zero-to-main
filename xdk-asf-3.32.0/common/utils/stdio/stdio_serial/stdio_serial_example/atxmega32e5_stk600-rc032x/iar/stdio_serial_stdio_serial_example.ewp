# IAR project stdio_serial_stdio_serial_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../xmega/boards/stk600/rc032x; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/utils; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../..; ../../../../../../services/serial/xmega_usart; ../../../../../../services/gpio; ..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../: stdio_serial.h
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/utils/stdio/stdio_serial/stdio_serial_example/atxmega32e5_stk600-rc032x
    ../: conf_clock.h conf_board.h conf_usart_serial.h
  group common/utils/stdio/stdio_serial/stdio_serial_example/atxmega32e5_stk600-rc032x/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_avr8.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../../../services/serial/xmega_usart/: usart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
  group xmega/boards/stk600/rc032x
    ../../../../../../../xmega/boards/stk600/rc032x/: init.c stk600_rc032x.h led.h
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/utils
    ../../../../../../../xmega/utils/: compiler.h status_codes.h assembler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
