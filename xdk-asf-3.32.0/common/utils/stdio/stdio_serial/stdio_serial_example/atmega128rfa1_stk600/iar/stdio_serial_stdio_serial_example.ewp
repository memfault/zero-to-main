# IAR project stdio_serial_stdio_serial_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../../../mega/boards/stk600; ../../../../../../services/serial/megarf_usart; ../../../../../../../mega/utils/preprocessor; ../../../../../../../mega/utils; ../../../../../../services/serial; ../../../../../../services/clock; ../../..; ../../../../../../boards; ../../../../../../services/ioport; ..; ../../../../..; ../../../../../../../mega/boards/stk600/rc128x_rfx; ../../../../../../services/gpio; ../../../../../../../mega/drivers/usart; ../../../../../../../mega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../: stdio_serial.h
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/utils/stdio/stdio_serial/stdio_serial_example/atmega128rfa1_stk600
    ../: conf_clock.h conf_board.h conf_usart_serial.h
  group common/utils/stdio/stdio_serial/stdio_serial_example/atmega128rfa1_stk600/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_avr8.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../services/serial/megarf_usart/: usart_serial.h
  group common/services/clock
    ../../../../../../services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../services/clock/mega/: sysclk.c sysclk.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../services/ioport/mega/: ioport.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../services/gpio/mega_gpio/: mega_gpio.h
  group common/boards
    ../../../../../../boards/: board.h
  group mega/drivers/usart
    ../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/boards/stk600/rc128x_rfx
    ../../../../../../../mega/boards/stk600/rc128x_rfx/: init.c stk600.h led.h
  group mega/utils
    ../../../../../../../mega/utils/: status_codes.h progmem.h assembler.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../mega/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../mega/utils/assembler/: iar.h
