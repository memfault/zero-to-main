# IAR project stdio_serial_stdio_serial_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/header_files; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ..; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/drivers/usart; ../../..; ../../../../../../boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/fpu; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../..; ../../../../../../../sam/boards/sam4e_ek; ../../../../../../services/serial; ../../../../../../services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_serial_stdio_serial_example_flash.bin
  ILINK.IlinkOutputFile: stdio_serial_stdio_serial_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../: interrupt.h parts.h
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../: stdio_serial.h
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/utils/stdio/stdio_serial/stdio_serial_example/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group common/utils/stdio/stdio_serial/stdio_serial_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam4e
    ../../../../../../services/clock/sam4e/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e.h sam4e8c.h sam4e16cb.h sam4e8e.h sam4e8cb.h sam4e16c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16c.h sam4e8c.h sam4e8e.h sam4e8cb.h sam4e16cb.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../sam/utils/cmsis/sam4e/include/component/: aes.h pdc.h rtt.h gpbr.h gmac.h pio.h rswdt.h efc.h uart.h tc.h smc.h dmac.h afec.h usart.h wdt.h twi.h hsmci.h pmc.h udp.h supc.h rtc.h can.h acc.h rstc.h chipid.h matrix.h cmcc.h spi.h pwm.h dacc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../sam/utils/cmsis/sam4e/include/instance/: udp.h uart0.h pmc.h aes.h afec0.h twi1.h can0.h afec1.h piod.h matrix.h piob.h can1.h efc.h chipid.h twi0.h dmac.h tc0.h rtc.h rswdt.h pwm.h wdt.h rtt.h gpbr.h tc2.h gmac.h hsmci.h supc.h tc1.h acc.h rstc.h usart0.h spi.h uart1.h cmcc.h smc.h dacc.h pioa.h pioe.h usart1.h pioc.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/sam4e_ek
    ../../../../../../../sam/boards/sam4e_ek/: init.c led.h sam4e_ek.h
