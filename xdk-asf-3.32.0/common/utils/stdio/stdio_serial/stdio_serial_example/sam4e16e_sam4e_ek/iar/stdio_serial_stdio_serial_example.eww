<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\stdio_serial_stdio_serial_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\stdio_serial_stdio_serial_example_sram.ewp</path>
	</project>
</workspace>
