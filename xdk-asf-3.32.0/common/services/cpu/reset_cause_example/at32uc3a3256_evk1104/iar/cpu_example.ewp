# IAR project cpu_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../avr32/drivers/cpu; ../../../../../../avr32/drivers/gpio; ../../..; ../../../../clock; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards/evk1104; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu
    ../../../../../../avr32/drivers/cpu/: avr32_reset_cause.h
  group avr32/boards/evk1104
    ../../../../../../avr32/boards/evk1104/: init.c led.c evk1104.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/clock
    ../../../../clock/: genclk.h sysclk.h pll.h osc.h
  group common/services/clock/uc3a3_a4
    ../../../../clock/uc3a3_a4/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/cpu
    ../../../: reset_cause.h
  group common/services/cpu/reset_cause_example
    ../../: reset_cause_example.c
  group common/services/cpu/reset_cause_example/at32uc3a3256_evk1104
    ../: conf_clock.h conf_board.h
  group common/services/cpu/reset_cause_example/at32uc3a3256_evk1104/iar
    ./: asf.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
