<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cpu_example_flash.ewp</path>
	</project>
</workspace>
