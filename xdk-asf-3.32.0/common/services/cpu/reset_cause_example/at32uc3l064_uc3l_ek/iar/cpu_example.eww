<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\cpu_example.ewp</path>
	</project>
</workspace>
