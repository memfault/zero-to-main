# IAR project gfx_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../delay; ../../../../../components/display/ili9341; ../../..; ../../../../clock; ../../../../../../avr32/drivers/spi; ../../../../spi; ../../../../../../avr32/boards/uc3_l0_xplained; ../../../../../boards; ../../../../../../avr32/boards; ../../../../ioport; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../utils; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/flashcdw; ..; ../../../../../../avr32/drivers/pdca; ../../../../spi/uc3_spi; ../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../clock/: genclk.h sysclk.h dfll.h osc.h
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c genclk.h osc.h dfll.h sysclk.h
  group common/services/gfx
    ../../../: gfx_text.c gfx_generic.c sysfont.c gfx_ili9341_sdt028atft.c gfx_text.h sysfont.h gfx.h gfx_generic.h gfx_ili9341_sdt028atft.h
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/gfx/example1/at32uc3l064_uc3_l0_xplained
    ../: conf_ili9341.h conf_clock.h conf_board.h atmel_logo.h conf_sysfont.h smiley.h conf_spi_master.h
  group common/services/gfx/example1/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group common/services/spi
    ../../../../spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../ioport/uc3/: ioport.h
  group common/components/display/ili9341
    ../../../../../components/display/ili9341/: ili9341.c ili9341.h ili9341_regs.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/pdca
    ../../../../../../avr32/drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c uc3_l0_xplained.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
