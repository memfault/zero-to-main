# IAR project gfx_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: GFX_INITIALIZED=1; CONF_GFX_HX8347A_ET024006DHU_EBI=1; BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/boards/evk1105; ../../../../../../avr32/components/display/et024006dhu; ../../..; ..; ../../../../clock; ../../../../../../avr32/drivers/ebi/smc; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/flashc; ../../../../ioport; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; ../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/ebi/smc
    ../../../../../../avr32/drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1105
    ../../../../../../avr32/boards/evk1105/: init.c led.c evk1105.h led.h
  group avr32/components/display/et024006dhu
    ../../../../../../avr32/components/display/et024006dhu/: et024006dhu.c et024006dhu.h smc_et024006dhu.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/gfx
    ../../../: gfx_generic.c sysfont.c gfx_hx8347a_et024006dhu_ebi.c gfx_text.c gfx_text.h sysfont.h gfx.h gfx_generic.h gfx_hx8347a_et024006dhu_ebi.h
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/gfx/example1/at32uc3a0512_evk1105
    ../: conf_clock.h conf_ebi.h conf_board.h atmel_logo.h conf_sysfont.h conf_et024006dhu.h smiley.h
  group common/services/gfx/example1/at32uc3a0512_evk1105/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/uc3a0_a1
    ../../../../clock/uc3a0_a1/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../ioport/uc3/: ioport.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
