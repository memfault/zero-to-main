# IAR project gfx_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../delay; ../../../../../components/display/ili9341; ../../..; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../gpio; ../../../../spi; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/utils; ../../../../../../xmega/boards/xmega_a1_xplained; ..; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../../xmega/utils/preprocessor; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/gfx
    ../../../: gfx_text.c gfx_generic.c sysfont.c gfx_ili9341_sdt028atft.c gfx_text.h sysfont.h gfx.h gfx_generic.h gfx_ili9341_sdt028atft.h
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/gfx/example1/atxmega128a1_xmega_a1_xplained
    ../: conf_usart_spi.h conf_sysfont.h conf_ili9341.h smiley.h conf_board.h atmel_logo.h conf_clock.h
  group common/services/gfx/example1/atxmega128a1_xmega_a1_xplained/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h sysclk.h pll.h osc.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/spi
    ../../../../spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/xmega
    ../../../../delay/xmega/: cycle_counter.h
  group common/components/display/ili9341
    ../../../../../components/display/ili9341/: ili9341.c ili9341.h ili9341_regs.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../../xmega/boards/xmega_a1_xplained/: init.c xmega_a1_xplained.h led.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
