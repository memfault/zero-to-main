<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_example.ewp</path>
	</project>
</workspace>
