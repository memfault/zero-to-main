# IAR project sleepmgr_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../../mega/boards/stk600; ../../../../serial/megarf_usart; ..; ../../../../../../mega/utils/preprocessor; ../../../../../../mega/utils; ../../../../clock; ../../../../../../mega/drivers/cpu; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../mega/boards/stk600/rc128x_rfx; ../../../../../../mega/drivers/sleep; ../../../../ioport; ../..; ../../..; ../../../../../utils; ../../../../../../mega/drivers/usart; ../../../../gpio; ../../../../serial; ../../../../../../mega/drivers/adc; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=STK600_MEGA_RF
  group mega/boards/stk600/rc128x_rfx
    ../../../../../../mega/boards/stk600/rc128x_rfx/: init.c led.h stk600.h
  group mega/drivers/usart
    ../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/drivers/adc
    ../../../../../../mega/drivers/adc/: adc_megarf.h adc.h
  group mega/drivers/sleep
    ../../../../../../mega/drivers/sleep/: sleep_megarf.h sleep.h
  group mega/utils
    ../../../../../../mega/utils/: status_codes.h assembler.h progmem.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../mega/utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group mega/utils/assembler
    ../../../../../../mega/utils/assembler/: iar.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/services/clock
    ../../../../clock/: sysclk.h
  group common/services/clock/mega
    ../../../../clock/mega/: sysclk.c sysclk.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/unit_tests
    ../../: unit_tests.c
  group common/services/sleepmgr/unit_tests/atmega128rfa1_stk600-rc128x_rfx
    ../: conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group common/services/sleepmgr/unit_tests/atmega128rfa1_stk600-rc128x_rfx/iar
    ./: asf.h
  group common/services/sleepmgr/mega
    ../../../mega/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../serial/megarf_usart/: usart_serial.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../ioport/mega/: ioport.h
  group common/boards
    ../../../../../boards/: board.h
