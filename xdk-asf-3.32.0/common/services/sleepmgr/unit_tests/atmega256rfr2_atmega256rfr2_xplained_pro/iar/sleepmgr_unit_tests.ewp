# IAR project sleepmgr_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: ../../../../serial/megarf_usart; ../../../../../../mega/utils/preprocessor; ../../../../../../mega/utils; ../../../../clock; ../../../../../../mega/boards; ../../../../../../mega/drivers/cpu; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../mega/drivers/sleep; ..; ../../../../ioport; ../..; ../../..; ../../../../../utils; ../../../../../../mega/drivers/usart; ../../../../../../mega/boards/atmega256rfr2_xplained_pro; ../../../../gpio; ../../../../serial; ../../../../../../mega/drivers/adc; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/services/clock
    ../../../../clock/: sysclk.h
  group common/services/clock/mega
    ../../../../clock/mega/: sysclk.c sysclk.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/unit_tests
    ../../: unit_tests.c
  group common/services/sleepmgr/unit_tests/atmega256rfr2_atmega256rfr2_xplained_pro
    ../: conf_test.h conf_clock.h conf_board.h conf_sleepmgr.h conf_usart_serial.h
  group common/services/sleepmgr/unit_tests/atmega256rfr2_atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group common/services/sleepmgr/mega
    ../../../mega/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../serial/megarf_usart/: usart_serial.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../ioport/mega/: ioport.h
  group common/boards
    ../../../../../boards/: board.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/drivers/usart
    ../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/sleep
    ../../../../../../mega/drivers/sleep/: sleep_megarf.h sleep.h
  group mega/drivers/cpu
    ../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/drivers/adc
    ../../../../../../mega/drivers/adc/: adc_megarf.h adc.h
  group mega/utils
    ../../../../../../mega/utils/: status_codes.h assembler.h progmem.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../mega/utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group mega/utils/assembler
    ../../../../../../mega/utils/assembler/: iar.h
