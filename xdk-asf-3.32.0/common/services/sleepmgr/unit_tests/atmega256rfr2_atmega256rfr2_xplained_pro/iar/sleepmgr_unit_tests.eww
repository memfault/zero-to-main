<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sleepmgr_unit_tests.ewp</path>
	</project>
</workspace>
