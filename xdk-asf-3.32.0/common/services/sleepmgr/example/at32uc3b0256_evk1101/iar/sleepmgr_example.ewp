# IAR project sleepmgr_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../clock; ..; ../../../../../../avr32/boards/evk1101; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/rtc; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../..; ../../../../../utils; ../../../../../../avr32/drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h pm.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/eic
    ../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/rtc
    ../../../../../../avr32/drivers/rtc/: rtc.c rtc.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/evk1101
    ../../../../../../avr32/boards/evk1101/: led.c init.c led.h evk1101.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../uc3/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_uc3_rtc.c
  group common/services/sleepmgr/example/at32uc3b0256_evk1101
    ../: conf_sleepmgr.h conf_board.h conf_example.h conf_clock.h
  group common/services/sleepmgr/example/at32uc3b0256_evk1101/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/uc3b0_b1
    ../../../../clock/uc3b0_b1/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
