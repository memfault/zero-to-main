# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  ICCARM.CCIncludePath2: ../../../../delay; ../../../../../../sam/drivers/rtt; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ..; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4cp/source/templates; ../../../../../../sam/drivers/supc; ../../..; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4cp/include; ../../../../../../sam/boards/sam4cp16bmb; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4CP16BMB; ARM_MATH_CM4=true; __SAM4CP16B_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../clock/: pll.h genclk.h sysclk.h osc.h
  group common/services/clock/sam4cp
    ../../../../clock/sam4cp/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../sam/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam_rtt.c
  group common/services/sleepmgr/example/sam4cp16b_sam4cp16bmb
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/sleepmgr/example/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rtt
    ../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/boards/sam4cp16bmb
    ../../../../../../sam/boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../sam/utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../sam/utils/cmsis/sam4cp/include/: sam4cp_0.h system_sam4cp.h sam4cp.h sam4cp16b_0.h sam4cp16b_1.h sam4cp_1.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../sam/utils/cmsis/sam4cp/include/instance/: instance_usart4.h instance_usart2.h instance_ipc1.h instance_spi0.h instance_usart0.h instance_rswdt.h instance_matrix0.h instance_smc1.h instance_icm.h instance_tc0.h instance_uart0.h instance_supc.h instance_uart1.h instance_wdt.h instance_rtc.h instance_trng.h instance_twi1.h instance_pioc.h instance_smc0.h instance_gpbr.h instance_rtt.h instance_twi0.h instance_slcdc.h instance_efc.h instance_rstc.h instance_pioa.h instance_piob.h instance_pwm.h instance_spi1.h instance_usart3.h instance_ipc0.h instance_usart1.h instance_matrix1.h instance_aes.h instance_chipid.h instance_cmcc0.h instance_tc1.h instance_adc.h instance_cmcc1.h instance_pmc.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../sam/utils/cmsis/sam4cp/include/component/: component_supc.h component_rtc.h component_adc.h component_tc.h component_pio.h component_usart.h component_smc.h component_gpbr.h component_cmcc.h component_ipc.h component_chipid.h component_spi.h component_aes.h component_icm.h component_matrix.h component_pdc.h component_efc.h component_slcdc.h component_trng.h component_pmc.h component_uart.h component_twi.h component_wdt.h component_rstc.h component_rtt.h component_rswdt.h component_pwm.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../sam/utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
