# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../sam/boards/samg53_xplained_pro; ../../../../delay; ../../../../../../sam/utils/cmsis/samg/samg53/include; ../../../../../../sam/utils; ../../../../../../sam/utils/fpu; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/efc; ../../../../clock; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/supc; ../../..; ../../../../../utils; ../../../../../../sam/utils/cmsis/samg/samg53/source/templates; ..; ../../../../../../sam/drivers/rtt; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/rtt
    ../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg53/source/templates/: exceptions.c system_samg53.c system_samg53.h exceptions.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../../../sam/utils/cmsis/samg/samg53/include/: samg53g19.h samg53n19.h samg53.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../../../sam/utils/cmsis/samg/samg53/include/component/: component_matrix.h component_usart.h component_efc.h component_pdc.h component_pmc.h component_twi.h component_tc.h component_chipid.h component_twihs.h component_uart.h component_adc.h component_i2sc.h component_supc.h component_rtc.h component_gpbr.h component_mem2mem.h component_pio.h component_rtt.h component_wdt.h component_rstc.h component_spi.h component_pdmic.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg53/include/instance/: instance_twi1.h instance_uart0.h instance_tc0.h instance_pioa.h instance_usart.h instance_rstc.h instance_pmc.h instance_matrix.h instance_supc.h instance_pdmic1.h instance_twi0.h instance_adc.h instance_twi2.h instance_wdt.h instance_spi.h instance_rtt.h instance_piob.h instance_gpbr.h instance_tc1.h instance_efc.h instance_i2sc1.h instance_i2sc0.h instance_mem2mem.h instance_pdmic0.h instance_rtc.h instance_chipid.h instance_uart1.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/samg53_xplained_pro
    ../../../../../../sam/boards/samg53_xplained_pro/: board_init.c samg53_xplained_pro.h led.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/samg
    ../../../../clock/samg/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../sam/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam_rtt.c
  group common/services/sleepmgr/example/samg53n19_samg_xplained_pro
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/sleepmgr/example/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../boards/: board.h
