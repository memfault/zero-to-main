<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sleepmgr_example_flash.ewp</path>
	</project>
</workspace>
