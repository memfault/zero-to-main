# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../sam/drivers/wdt; ../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../delay; ..; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/drivers/flashcalw; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/ast/example1; ../../../../../../sam/utils/preprocessor; ../../../../../boards; ../../../../../../sam/drivers/ast/example2; ../../..; ../../../../ioport; ../../../../../../sam/drivers/ast; ../../../../../../sam/boards; ../../../../../../sam/drivers/bpm; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../sam/boards/sam4l_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../sam/utils/cmsis/sam4l/include/: sam4lc4b.h sam4lc2b.h sam4l.h sam4lc8a.h sam4lc8c.h sam4ls4c.h sam4ls8a.h sam4ls4a.h sam4lc8b.h sam4ls8c.h sam4ls2c.h sam4ls2a.h sam4lc4a.h sam4ls4b.h sam4lc2a.h sam4lc4c.h sam4lc2c.h sam4ls8b.h sam4ls2b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_bscif.h instance_aesa.h instance_adcife.h instance_picouart.h instance_freqm.h instance_parc.h instance_spi.h instance_tc1.h instance_usbc.h instance_iisc.h instance_hflashc.h instance_abdacb.h instance_eic.h instance_acifc.h instance_tc0.h instance_pevc.h instance_twis0.h instance_trng.h instance_gpio.h instance_lcdca.h instance_bpm.h instance_scif.h instance_hcache.h instance_twim1.h instance_gloc.h instance_twis1.h instance_twim0.h instance_hmatrix.h instance_usart0.h instance_pdca.h instance_wdt.h instance_chipid.h instance_usart2.h instance_crccu.h instance_catb.h instance_twim2.h instance_twim3.h instance_pm.h instance_usart3.h instance_usart1.h instance_ast.h instance_dacc.h instance_smap.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc2a.h pio_sam4lc2c.h pio_sam4lc2b.h pio_sam4ls8a.h pio_sam4ls2a.h pio_sam4ls2b.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4lc4c.h pio_sam4lc4a.h pio_sam4ls8b.h pio_sam4ls4b.h pio_sam4lc4b.h pio_sam4lc8c.h pio_sam4lc8b.h pio_sam4lc8a.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../sam/utils/cmsis/sam4l/include/component/: component_scif.h component_usart.h component_ast.h component_twim.h component_iisc.h component_parc.h component_wdt.h component_usbc.h component_gloc.h component_hmatrixb.h component_tc.h component_gpio.h component_picouart.h component_twis.h component_bscif.h component_hcache.h component_dacc.h component_lcdca.h component_flashcalw.h component_pevc.h component_acifc.h component_catb.h component_eic.h component_crccu.h component_trng.h component_chipid.h component_pdca.h component_abdacb.h component_smap.h component_adcife.h component_bpm.h component_freqm.h component_aesa.h component_pm.h component_spi.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/ast
    ../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/ast/example1
    ../../../../../../sam/drivers/ast/example1/: ast_example1.h
  group sam/drivers/ast/example2
    ../../../../../../sam/drivers/ast/example2/: ast_example2.h
  group sam/drivers/bpm
    ../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/flashcalw
    ../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/boards/sam4l_ek
    ../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c sam4l_ek.h board_monitor.h led.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../sam4l/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam4l_ast.c
  group common/services/sleepmgr/example/sam4lc4c_sam4l_ek
    ../: conf_ast.h conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/sleepmgr/example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h dfll.h genclk.h sysclk.h
  group common/services/clock/sam4l
    ../../../../clock/sam4l/: sysclk.c dfll.c pll.c osc.c genclk.h osc.h dfll.h pll.h sysclk.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
