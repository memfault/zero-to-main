# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../../../delay; ../../../../../../sam/drivers/rtt; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/cmsis/sam4c/include; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/sam4c/source/templates; ../../../../../../sam/boards/sam4c_ek; ../../../../ioport; ../../../../../../sam/drivers/pmc; ..; ../../../../../../sam/drivers/supc; ../../..; ../../../../../utils; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rtt
    ../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/boards/sam4c_ek
    ../../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../sam/utils/cmsis/sam4c/include/: sam4c.h system_sam4c.h sam4c32e_0.h sam4c4c_0.h sam4c16c_1.h sam4c4c_1.h sam4c32c_1.h sam4c16c_0.h sam4c8c_1.h sam4c8c_0.h sam4c32e_1.h sam4c32c_0.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../sam/utils/cmsis/sam4c/include/component/: component_pmc.h component_pdc.h component_twi.h component_matrix.h component_wdt.h component_icm.h component_uart.h component_rtc.h component_chipid.h component_aes.h component_ipc.h component_usart.h component_rswdt.h component_smc.h component_spi.h component_trng.h component_pio.h component_tc.h component_uotghs.h component_efc.h component_pwm.h component_slcdc.h component_cmcc.h component_adc.h component_rtt.h component_rstc.h component_supc.h component_gpbr.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_uart0.h instance_smc0.h instance_twi1.h instance_efc.h instance_smc1.h instance_pwm.h instance_slcdc.h instance_chipid.h instance_tc1.h instance_cmcc0.h instance_rswdt.h instance_wdt.h instance_rtt.h instance_uart1.h instance_pmc.h instance_rstc.h instance_spi0.h instance_piod.h instance_tc0.h instance_cmcc1.h instance_piob.h instance_icm.h instance_aes.h instance_pioa.h instance_matrix1.h instance_spi1.h instance_usart3.h instance_ipc0.h instance_rtc.h instance_usart1.h instance_usart4.h instance_pioc.h instance_efc1.h instance_trng.h instance_gpbr.h instance_supc.h instance_twi0.h instance_uotghs.h instance_adc.h instance_efc0.h instance_matrix0.h instance_ipc1.h instance_usart2.h instance_usart0.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c4c.h pio_sam4c16c.h pio_sam4c32c.h pio_sam4c32e.h pio_sam4c8c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4c
    ../../../../clock/sam4c/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../sam/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam_rtt.c
  group common/services/sleepmgr/example/sam4c16c_sam4c_ek
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/sleepmgr/example/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
