# IAR project sleepmgr_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/drivers/ast; ../../../../../../avr32/drivers/scif; ../../../../../../avr32/boards/uc3l_ek; ../../../../../boards; ../../../../../../avr32/boards; ../../../../clock; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; ../../..; ../../../../../../avr32/drivers/flashcdw; ../../../../../../avr32/drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../clock/: genclk.h dfll.h osc.h sysclk.h
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c genclk.h osc.h sysclk.h dfll.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_uc3_ast.c
  group common/services/sleepmgr/example/at32uc3l064_uc3l_ek
    ../: conf_example.h conf_sleepmgr.h conf_board.h conf_clock.h
  group common/services/sleepmgr/example/at32uc3l064_uc3l_ek/iar
    ./: asf.h
  group common/services/sleepmgr/uc3
    ../../../uc3/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm_uc3l.c power_clocks_lib.c pm_uc3l.h sleep.h power_clocks_lib.h
  group avr32/drivers/eic
    ../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/ast
    ../../../../../../avr32/drivers/ast/: ast.c ast.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3l_ek
    ../../../../../../avr32/boards/uc3l_ek/: init.c led.c uc3l_ek.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
