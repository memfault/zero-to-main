# IAR project sleepmgr_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: ..; ../../../../delay; ../../../../../../mega/drivers/cpu; ../../../../../../mega/utils; ../../../../clock; ../../../../../../mega/boards; ../../../../../boards; ../../../../../../mega/drivers/sleep; ../../../../ioport; ../../..; ../../../../../utils; ../../../../../../mega/boards/atmega256rfr2_xplained_pro; ../../../../gpio; ../../../../../../mega/utils/preprocessor; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_megarf.c
  group common/services/sleepmgr/example/atmega256rfr2_atmega256rfr2_xplained_pro
    ../: conf_clock.h conf_example.h conf_board.h conf_sleepmgr.h
  group common/services/sleepmgr/example/atmega256rfr2_atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group common/services/sleepmgr/mega
    ../../../mega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../clock/: sysclk.h
  group common/services/clock/mega
    ../../../../clock/mega/: sysclk.c sysclk.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../ioport/mega/: ioport.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/mega
    ../../../../delay/mega/: cycle_counter.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/drivers/sleep
    ../../../../../../mega/drivers/sleep/: sleep_megarf.h sleep.h
  group mega/drivers/cpu
    ../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../mega/utils/: status_codes.h assembler.h progmem.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../mega/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group mega/utils/assembler
    ../../../../../../mega/utils/assembler/: iar.h
