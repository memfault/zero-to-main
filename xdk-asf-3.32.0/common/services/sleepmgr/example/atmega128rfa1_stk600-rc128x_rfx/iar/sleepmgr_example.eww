<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sleepmgr_example.ewp</path>
	</project>
</workspace>
