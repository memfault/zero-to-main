# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../delay; ../../../../../../sam/drivers/rtt; ../../../../../../sam/utils; ../../../../../../sam/utils/fpu; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ..; ../../../../../../sam/utils/preprocessor; ../../../../clock; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/supc; ../../..; ../../../../../utils; ../../../../../../sam/utils/cmsis/samg/samg55/source/templates; ../../../../../../sam/utils/cmsis/samg/samg55/include; ../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAMG55_XPLAINED_PRO; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rtt
    ../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../sam/boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h samg55j18.h samg55n19.h samg55j19.h samg55g19.h system_samg55.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: usart2.h spi4.h flexcom5.h pdmic0.h usart4.h efc.h rtt.h cmcc.h spi2.h twi7.h mem2mem.h supc.h usart6.h twi1.h flexcom1.h usart0.h flexcom3.h twi3.h usart3.h usart5.h spi7.h twi5.h i2sc1.h pioa.h crccu.h piob.h matrix.h pdmic1.h i2sc0.h usart7.h twi6.h twi0.h flexcom0.h flexcom2.h usart1.h uhp.h tc0.h twi2.h twi4.h spi1.h rstc.h chipid.h flexcom4.h flexcom7.h udp.h spi5.h wdt.h spi3.h gpbr.h rtc.h adc.h spi0.h pmc.h tc1.h spi6.h flexcom6.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: pmc.h flexcom.h pdc.h rtt.h rstc.h chipid.h gpbr.h i2sc.h wdt.h supc.h spi.h uhp.h pdmic.h tc.h udp.h cmcc.h twi.h efc.h rtc.h crccu.h mem2mem.h usart.h adc.h pio.h matrix.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55j18.h samg55n19.h samg55g18.h samg55g19.h samg55j19.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/samg
    ../../../../clock/samg/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../sam/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam_rtt.c
  group common/services/sleepmgr/example/samg55j19_samg_xplained_pro
    ../: conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h
  group common/services/sleepmgr/example/samg55j19_samg_xplained_pro/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../boards/: board.h
