# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4n/include; ../../../../../../sam/drivers/rtt; ../../../../../../sam/utils; ../../../../../../sam/utils/cmsis/sam4n/source/templates; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/boards/sam4n_xplained_pro; ..; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/supc; ../../..; ../../../../../utils; ../../../../../../sam/utils/header_files; ../../../../delay; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam4n_xplained_pro
    ../../../../../../sam/boards/sam4n_xplained_pro/: init.c led.h sam4n_xplained_pro.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rtt
    ../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../../sam/utils/cmsis/sam4n/source/templates/: exceptions.c system_sam4n.c exceptions.h system_sam4n.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../../sam/utils/cmsis/sam4n/include/: sam4n8a.h sam4n16b.h sam4n.h sam4n8c.h sam4n8b.h sam4n16c.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../../sam/utils/cmsis/sam4n/include/instance/: instance_rtc.h instance_twi0.h instance_supc.h instance_twi2.h instance_piob.h instance_uart3.h instance_uart1.h instance_rtt.h instance_tc0.h instance_dacc.h instance_adc.h instance_pmc.h instance_spi.h instance_uart2.h instance_uart0.h instance_tc1.h instance_pwm.h instance_chipid.h instance_usart0.h instance_usart2.h instance_gpbr.h instance_twi1.h instance_efc.h instance_pioc.h instance_pioa.h instance_usart1.h instance_wdt.h instance_matrix.h instance_rstc.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../../sam/utils/cmsis/sam4n/include/component/: component_uart.h component_efc.h component_spi.h component_dacc.h component_rstc.h component_rtc.h component_usart.h component_pmc.h component_rtt.h component_adc.h component_pio.h component_pdc.h component_supc.h component_tc.h component_wdt.h component_chipid.h component_gpbr.h component_pwm.h component_matrix.h component_twi.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../../sam/utils/cmsis/sam4n/include/pio/: pio_sam4n8c.h pio_sam4n8a.h pio_sam4n16c.h pio_sam4n16b.h pio_sam4n8b.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4n
    ../../../../clock/sam4n/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../sam/: sleepmgr.c sleepmgr.h
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam_rtt.c
  group common/services/sleepmgr/example/sam4n16c_sam4n_xplained_pro
    ../: conf_board.h conf_sleepmgr.h conf_example.h conf_clock.h
  group common/services/sleepmgr/example/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
