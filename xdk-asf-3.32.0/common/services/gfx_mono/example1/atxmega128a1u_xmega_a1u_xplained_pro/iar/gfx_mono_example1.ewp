# IAR project gfx_mono_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: BOARD=XMEGA_A1U_XPLAINED_PRO; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/spi; ../../../../delay; ..; ../../../../clock; ../../../../spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../..; ../../../../spi/xmega_spi; ../../../../ioport; ../../../../../components/display/ssd1306; ../../../../../../xmega/boards/xmega_a1u_xplained_pro; ../../../../../../xmega/drivers/nvm; ../../../../../../xmega/boards; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1U_XPLAINED_PRO; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/spi
    ../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/boards/xmega_a1u_xplained_pro
    ../../../../../../xmega/boards/xmega_a1u_xplained_pro/: board_init.c xmega_a1u_xplained_pro.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/components/display/ssd1306
    ../../../../../components/display/ssd1306/: ssd1306.c font.c ssd1306.h font.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/gfx_mono
    ../../../: gfx_mono_ug_2832hsweg04.c gfx_mono_framebuffer.c gfx_mono_generic.c gfx_mono_framebuffer.h gfx_mono_generic.h gfx_mono.h gfx_mono_ug_2832hsweg04.h
  group common/services/gfx_mono/example1
    ../../: example1.c
  group common/services/gfx_mono/example1/atxmega128a1u_xmega_a1u_xplained_pro
    ../: conf_ssd1306.h conf_clock.h conf_board.h conf_spi_master.h
  group common/services/gfx_mono/example1/atxmega128a1u_xmega_a1u_xplained_pro/iar
    ./: asf.h
  group common/services/spi
    ../../../../spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/xmega
    ../../../../delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
