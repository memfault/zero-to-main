<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gfx_mono_example1.ewp</path>
	</project>
</workspace>
