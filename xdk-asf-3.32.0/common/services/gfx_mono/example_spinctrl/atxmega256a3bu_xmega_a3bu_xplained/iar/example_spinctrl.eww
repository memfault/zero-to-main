<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_spinctrl.ewp</path>
	</project>
</workspace>
