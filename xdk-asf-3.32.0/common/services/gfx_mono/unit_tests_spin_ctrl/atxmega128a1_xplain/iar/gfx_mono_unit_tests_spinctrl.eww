<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gfx_mono_unit_tests_spinctrl.ewp</path>
	</project>
</workspace>
