<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\gfx_mono_unit_test_menu.ewp</path>
	</project>
</workspace>
