<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ioport_example3_flash.ewp</path>
	</project>
</workspace>
