<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ioport_unit_tests.ewp</path>
	</project>
</workspace>
