<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ioport_example2.ewp</path>
	</project>
</workspace>
