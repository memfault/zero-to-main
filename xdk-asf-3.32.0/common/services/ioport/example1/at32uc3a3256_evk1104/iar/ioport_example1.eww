<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ioport_example1.ewp</path>
	</project>
</workspace>
