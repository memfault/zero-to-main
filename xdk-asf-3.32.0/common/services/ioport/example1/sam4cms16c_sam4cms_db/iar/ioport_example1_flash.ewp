# IAR project ioport_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  ICCARM.CCIncludePath2: ../../../../delay; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../..; ../..; ../../../../../../sam/boards/sam4cms_db; ..; ../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4cm/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ioport_example1_flash.bin
  ILINK.IlinkOutputFile: ioport_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms4c_1.h sam4cms8c_1.h sam4cmp16c_1.h sam4cms8c_0.h sam4cms4c_0.h sam4cmp8c_1.h sam4cmp16c_0.h sam4cms16c_0.h sam4cm.h sam4cmp8c_0.h sam4cms16c_1.h system_sam4cm.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../sam/utils/cmsis/sam4cm/include/instance/: slcdc.h trng.h uart1.h adc.h tc0.h chipid.h ipc0.h wdt.h tc1.h rswdt.h uart0.h pwm.h pioa.h icm.h spi1.h pmc.h rstc.h pioc.h usart2.h smc0.h efc.h rtc.h supc.h matrix0.h spi0.h usart0.h matrix1.h twi1.h piob.h cmcc1.h aes.h usart3.h smc1.h rtt.h twi0.h gpbr.h usart1.h ipc1.h cmcc0.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../sam/utils/cmsis/sam4cm/include/component/: chipid.h rtt.h tc.h pmc.h efc.h spi.h uart.h trng.h supc.h smc.h twi.h icm.h cmcc.h pdc.h aes.h gpbr.h rswdt.h usart.h pio.h ipc.h rstc.h wdt.h matrix.h adc.h rtc.h pwm.h slcdc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cms16c.h sam4cms4c.h sam4cmp16c.h sam4cmp8c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4cms_db
    ../../../../../../sam/boards/sam4cms_db/: init.c sam4cms_db.h led.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4cm
    ../../../../clock/sam4cm/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/ioport
    ../../../: ioport.h
  group common/services/ioport/example1
    ../../: ioport_example1.c
  group common/services/ioport/example1/sam4cms16c_sam4cms_db
    ../: conf_board.h conf_example.h conf_clock.h
  group common/services/ioport/example1/sam4cms16c_sam4cms_db/iar
    ./: asf.h
  group common/services/ioport/sam
    ../../../sam/: ioport_pio.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
