<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\calendar_example2.ewp</path>
	</project>
</workspace>
