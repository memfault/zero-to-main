# IAR project calendar_example2.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ..; ../../../../../../avr32/drivers/gpio; ../../../../clock; ../../../../../../avr32/boards/uc3_l0_xplained; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/flashcdw; ../../../../../../avr32/utils/preprocessor; ../..; ../../../../../utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../../clock/: genclk.h sysclk.h dfll.h osc.h
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c genclk.h osc.h sysclk.h dfll.h
  group common/services/calendar
    ../../../: calendar.c calendar.h
  group common/services/calendar/example2
    ../../: example2.c
  group common/services/calendar/example2/at32uc3l064_uc3_l0_xplained
    ../: conf_clock.h conf_board.h
  group common/services/calendar/example2/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c uc3_l0_xplained.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
