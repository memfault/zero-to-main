<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\calendar_unit_tests.ewp</path>
	</project>
</workspace>
