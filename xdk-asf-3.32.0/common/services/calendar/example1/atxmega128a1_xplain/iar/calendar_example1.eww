<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\calendar_example1.ewp</path>
	</project>
</workspace>
