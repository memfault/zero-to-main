<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\delay_example.ewp</path>
	</project>
</workspace>
