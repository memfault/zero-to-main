<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\delay_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\delay_example_sram.ewp</path>
	</project>
</workspace>
