# IAR project freertos_sam_spi_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3N4C Atmel ATSAM3N4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TEST_SUITE_DEFINE_ASSERT_MACRO; _ASSERT_ENABLE_; BOARD=SAM3N_EK; __SAM3N4C__; ARM_MATH_CM3=true; __FREERTOS__
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../spi/sam_spi; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../serial; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ..; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam3n_ek; ../..; ../../../../../../gpio; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../../../sam/drivers/usart; ../../../../../../serial/sam_uart; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_spi_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_spi_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c FreeRTOS_CLI.c timers.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: timers.h semphr.h task.h StackMacros.h queue.h FreeRTOS.h croutine.h mpu_wrappers.h FreeRTOS_CLI.h projdefs.h list.h portable.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam3n
    ../../../../../../clock/sam3n/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/spi
    ../../../../../../spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../spi/sam_spi/: spi_master.c spi_master.h
  group common/services/freertos/sam
    ../../../../: freertos_spi_master.c freertos_peripheral_control.c freertos_spi_master.h freertos_peripheral_control_private.h freertos_peripheral_control.h
  group common/services/freertos/sam/unit_tests/freertos_spi_master
    ../../: spi_unit_tests.c FreeRTOSConfig.h
  group common/services/freertos/sam/unit_tests/freertos_spi_master/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_example.h conf_test.h
  group common/services/freertos/sam/unit_tests/freertos_spi_master/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group common/services/ioport
    ../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c system_sam3n.h exceptions.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../../../sam/utils/cmsis/sam3n/include/: sam3n2a.h sam3n2c.h sam3n4b.h sam3n2b.h sam3n.h sam3n0c.h sam3n1a.h sam3n4a.h sam3n4c.h sam3n00b.h sam3n0b.h sam3n0a.h sam3n00a.h sam3n1b.h sam3n1c.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_pmc.h instance_rtt.h instance_wdt.h instance_spi.h instance_adc.h instance_pwm.h instance_uart0.h instance_matrix.h instance_usart1.h instance_gpbr.h instance_piob.h instance_tc1.h instance_chipid.h instance_uart1.h instance_tc0.h instance_usart0.h instance_rstc.h instance_pioa.h instance_efc.h instance_pioc.h instance_twi0.h instance_dacc.h instance_supc.h instance_rtc.h instance_twi1.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n0b.h pio_sam3n0c.h pio_sam3n0a.h pio_sam3n1c.h pio_sam3n4b.h pio_sam3n00b.h pio_sam3n2b.h pio_sam3n1b.h pio_sam3n1a.h pio_sam3n4c.h pio_sam3n4a.h pio_sam3n2a.h pio_sam3n00a.h pio_sam3n2c.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../../../sam/utils/cmsis/sam3n/include/component/: component_chipid.h component_gpbr.h component_twi.h component_adc.h component_matrix.h component_rtc.h component_dacc.h component_usart.h component_rstc.h component_pio.h component_supc.h component_pmc.h component_pdc.h component_wdt.h component_uart.h component_rtt.h component_tc.h component_efc.h component_pwm.h component_spi.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/boards/sam3n_ek
    ../../../../../../../../sam/boards/sam3n_ek/: init.c led.c led.h sam3n_ek.h
