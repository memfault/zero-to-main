# IAR project freertos_sam_twi_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Atmel ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__; __FREERTOS__
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/boards/sam3x_ek; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../components/memory/eeprom/at24cxx; ../../../../../../twi; ../../../../../../serial; ../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../clock; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../..; ../../../..; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../gpio; ../../../../../../delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ..; ../../../../../../serial/sam_uart; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_twi_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_twi_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c FreeRTOS_CLI.c timers.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: timers.h semphr.h task.h StackMacros.h croutine.h queue.h mpu_wrappers.h FreeRTOS.h FreeRTOS_CLI.h projdefs.h list.h portable.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/freertos/sam
    ../../../../: freertos_twi_master.c freertos_peripheral_control.c freertos_peripheral_control_private.h freertos_twi_master.h freertos_peripheral_control.h
  group common/services/freertos/sam/unit_tests/freertos_twi_master
    ../../: twi_unit_tests.c FreeRTOSConfig.h
  group common/services/freertos/sam/unit_tests/freertos_twi_master/sam3x8h_sam3x_ek
    ../: conf_example.h conf_uart_serial.h conf_clock.h conf_board.h conf_test.h
  group common/services/freertos/sam/unit_tests/freertos_twi_master/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam3x
    ../../../../../../clock/sam3x/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/twi
    ../../../../../../twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../ioport/sam/: ioport_pio.h
  group common/components/memory/eeprom/at24cxx
    ../../../../../../../components/memory/eeprom/at24cxx/: at24cxx.c at24cxx.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c system_sam3x.h exceptions.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8h.h sam3xa.h sam3a4c.h sam3x8e.h sam3x4c.h sam3x8c.h sam3a8c.h sam3x4e.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../../../sam/utils/cmsis/sam3x/include/component/: component_supc.h component_smc.h component_rstc.h component_can.h component_chipid.h component_hsmci.h component_dacc.h component_rtc.h component_uart.h component_pdc.h component_efc.h component_uotghs.h component_tc.h component_emac.h component_pio.h component_usart.h component_wdt.h component_pmc.h component_pwm.h component_dmac.h component_gpbr.h component_twi.h component_spi.h component_sdramc.h component_trng.h component_rtt.h component_matrix.h component_ssc.h component_adc.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_spi1.h instance_dmac.h instance_rtc.h instance_supc.h instance_dacc.h instance_piod.h instance_chipid.h instance_trng.h instance_uotghs.h instance_ssc.h instance_tc2.h instance_matrix.h instance_piob.h instance_emac.h instance_usart3.h instance_rstc.h instance_efc0.h instance_usart1.h instance_usart0.h instance_gpbr.h instance_hsmci.h instance_pioe.h instance_pmc.h instance_pwm.h instance_pioc.h instance_can0.h instance_pioa.h instance_usart2.h instance_adc.h instance_efc1.h instance_uart.h instance_sdramc.h instance_piof.h instance_can1.h instance_smc.h instance_wdt.h instance_rtt.h instance_twi1.h instance_twi0.h instance_tc0.h instance_tc1.h instance_spi0.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3x8e.h pio_sam3x8h.h pio_sam3x8c.h pio_sam3x4c.h pio_sam3a4c.h pio_sam3x4e.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3x_ek
    ../../../../../../../../sam/boards/sam3x_ek/: led.c init.c sam3x_ek.h led.h
