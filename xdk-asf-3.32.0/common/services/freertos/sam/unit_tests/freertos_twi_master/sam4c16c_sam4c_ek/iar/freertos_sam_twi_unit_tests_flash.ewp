# IAR project freertos_sam_twi_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; __SAM4C16C_0__; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; __FREERTOS__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../../components/memory/eeprom/at24cxx; ../../../../../../gpio; ../../../../../../serial; ../../../../../../../../sam/utils/cmsis/sam4c/source/templates; ../../../../../../clock; ../../../../../../../../sam/boards/sam4c_ek; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../..; ../../../..; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../twi; ../../../../../../delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam4c/include; ../../../../../../serial/sam_uart; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/drivers/twi; ../../../../../../../../sam/drivers/usart; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_twi_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_twi_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c FreeRTOS_CLI.c timers.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: timers.h semphr.h task.h queue.h StackMacros.h croutine.h mpu_wrappers.h FreeRTOS.h projdefs.h list.h FreeRTOS_CLI.h portable.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../../../sam/utils/cmsis/sam4c/include/: sam4c32c_0.h sam4c8c_1.h sam4c.h sam4c16c_0.h sam4c32e_1.h sam4c4c_0.h sam4c32e_0.h sam4c4c_1.h sam4c32c_1.h system_sam4c.h sam4c8c_0.h sam4c16c_1.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_matrix1.h instance_ipc1.h instance_adc.h instance_aes.h instance_uotghs.h instance_pwm.h instance_wdt.h instance_uart0.h instance_tc1.h instance_icm.h instance_efc0.h instance_pmc.h instance_rstc.h instance_matrix0.h instance_piob.h instance_gpbr.h instance_supc.h instance_twi0.h instance_uart1.h instance_tc0.h instance_cmcc0.h instance_usart1.h instance_spi0.h instance_rswdt.h instance_pioa.h instance_usart3.h instance_pioc.h instance_efc1.h instance_efc.h instance_twi1.h instance_smc1.h instance_rtt.h instance_spi1.h instance_chipid.h instance_ipc0.h instance_usart0.h instance_cmcc1.h instance_slcdc.h instance_usart2.h instance_rtc.h instance_usart4.h instance_trng.h instance_smc0.h instance_piod.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../../../sam/utils/cmsis/sam4c/include/component/: component_gpbr.h component_trng.h component_chipid.h component_rswdt.h component_supc.h component_tc.h component_pwm.h component_uart.h component_icm.h component_ipc.h component_slcdc.h component_uotghs.h component_pio.h component_smc.h component_matrix.h component_efc.h component_spi.h component_rstc.h component_adc.h component_usart.h component_pdc.h component_rtc.h component_aes.h component_cmcc.h component_wdt.h component_twi.h component_rtt.h component_pmc.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c4c.h pio_sam4c32c.h pio_sam4c8c.h pio_sam4c32e.h pio_sam4c16c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/boards/sam4c_ek
    ../../../../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/clock
    ../../../../../../clock/: osc.h genclk.h pll.h sysclk.h
  group common/services/clock/sam4c
    ../../../../../../clock/sam4c/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/freertos/sam
    ../../../../: freertos_twi_master.c freertos_peripheral_control.c freertos_peripheral_control_private.h freertos_twi_master.h freertos_peripheral_control.h
  group common/services/freertos/sam/unit_tests/freertos_twi_master
    ../../: twi_unit_tests.c FreeRTOSConfig.h
  group common/services/freertos/sam/unit_tests/freertos_twi_master/sam4c16c_sam4c_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_example.h conf_test.h
  group common/services/freertos/sam/unit_tests/freertos_twi_master/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group common/services/delay
    ../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/twi
    ../../../../../../twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../ioport/sam/: ioport_pio.h
  group common/components/memory/eeprom/at24cxx
    ../../../../../../../components/memory/eeprom/at24cxx/: at24cxx.c at24cxx.h
  group common/boards
    ../../../../../../../boards/: board.h
