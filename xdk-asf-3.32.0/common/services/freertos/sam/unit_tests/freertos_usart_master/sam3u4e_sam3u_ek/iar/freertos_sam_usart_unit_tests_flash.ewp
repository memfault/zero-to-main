# IAR project freertos_sam_usart_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U4E Atmel ATSAM3U4E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK; __FREERTOS__
  ICCARM.CCIncludePath2: ../../../../../../serial/sam_uart; ../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam; ..; ../../../../../../serial; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../gpio; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_usart_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_usart_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: timers.h semphr.h task.h StackMacros.h croutine.h queue.h mpu_wrappers.h FreeRTOS.h FreeRTOS_CLI.h projdefs.h list.h portable.h
  group common/services/freertos/sam
    ../../../../: freertos_usart_serial.c freertos_peripheral_control.c freertos_usart_serial.h freertos_peripheral_control_private.h freertos_peripheral_control.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master
    ../../: usart_unit_tests.c FreeRTOSConfig.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master/sam3u4e_sam3u_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h conf_example.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master/sam3u4e_sam3u_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam3u
    ../../../../../../clock/sam3u/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/boards/sam3u_ek
    ../../../../../../../../sam/boards/sam3u_ek/: led.c init.c led.h sam3u_ek.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c exceptions.h system_sam3u.h
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/sam3u/include
    ../../../../../../../../sam/utils/cmsis/sam3u/include/: sam3u2c.h sam3u.h sam3u2e.h sam3u4c.h sam3u1e.h sam3u1c.h sam3u4e.h
  group sam/utils/cmsis/sam3u/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3u/include/instance/: instance_piob.h instance_rstc.h instance_ssc.h instance_chipid.h instance_efc0.h instance_dmac.h instance_udphs.h instance_usart0.h instance_rtt.h instance_usart2.h instance_smc.h instance_rtc.h instance_pwm.h instance_usart1.h instance_matrix.h instance_pmc.h instance_wdt.h instance_twi0.h instance_adc.h instance_usart3.h instance_spi.h instance_hsmci.h instance_uart.h instance_pioc.h instance_twi1.h instance_adc12b.h instance_efc1.h instance_supc.h instance_gpbr.h instance_pioa.h instance_tc0.h
  group sam/utils/cmsis/sam3u/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3u/include/pio/: pio_sam3u2e.h pio_sam3u1c.h pio_sam3u1e.h pio_sam3u2c.h pio_sam3u4e.h pio_sam3u4c.h
  group sam/utils/cmsis/sam3u/include/component
    ../../../../../../../../sam/utils/cmsis/sam3u/include/component/: component_dmac.h component_rtt.h component_wdt.h component_tc.h component_gpbr.h component_pwm.h component_twi.h component_usart.h component_efc.h component_matrix.h component_supc.h component_adc.h component_rtc.h component_uart.h component_smc.h component_spi.h component_ssc.h component_udphs.h component_pdc.h component_pio.h component_pmc.h component_adc12b.h component_hsmci.h component_rstc.h component_chipid.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
