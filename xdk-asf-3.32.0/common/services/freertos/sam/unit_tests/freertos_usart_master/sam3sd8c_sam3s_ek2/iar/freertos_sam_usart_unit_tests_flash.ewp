# IAR project freertos_sam_usart_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3SD8C Atmel ATSAM3SD8C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM3S_EK2; _ASSERT_ENABLE_; __SAM3SD8C__; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM3=true; __FREERTOS__
  ICCARM.CCIncludePath2: ..; ../../../../../../serial/sam_uart; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../serial; ../../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam3s_ek2; ../../../../../../gpio; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_usart_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_usart_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: timers.h semphr.h task.h queue.h FreeRTOS.h StackMacros.h croutine.h mpu_wrappers.h FreeRTOS_CLI.h projdefs.h list.h portable.h
  group sam/boards/sam3s_ek2
    ../../../../../../../../sam/boards/sam3s_ek2/: init.c led.c led.h sam3s_ek2.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c system_sam3sd8.h exceptions.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/: sam3s8b.h sam3sd8c.h sam3s8.h sam3s8c.h sam3sd8b.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_chipid.h instance_gpbr.h instance_wdt.h instance_rtt.h instance_tc1.h instance_tc0.h instance_acc.h instance_pmc.h instance_pioa.h instance_usart0.h instance_hsmci.h instance_uart1.h instance_usart2.h instance_twi1.h instance_spi.h instance_smc.h instance_uart0.h instance_crccu.h instance_usart1.h instance_ssc.h instance_supc.h instance_dacc.h instance_adc.h instance_twi0.h instance_efc.h instance_pioc.h instance_matrix.h instance_udp.h instance_rstc.h instance_rtc.h instance_pwm.h instance_piob.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_pio.h component_supc.h component_tc.h component_rstc.h component_chipid.h component_rtc.h component_crccu.h component_matrix.h component_twi.h component_udp.h component_smc.h component_rtt.h component_spi.h component_adc.h component_efc.h component_gpbr.h component_pdc.h component_wdt.h component_dacc.h component_usart.h component_pwm.h component_ssc.h component_uart.h component_pmc.h component_hsmci.h component_acc.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3s8b.h pio_sam3sd8b.h pio_sam3s8c.h pio_sam3sd8c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/freertos/sam
    ../../../../: freertos_usart_serial.c freertos_peripheral_control.c freertos_usart_serial.h freertos_peripheral_control_private.h freertos_peripheral_control.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master
    ../../: usart_unit_tests.c FreeRTOSConfig.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master/sam3sd8c_sam3s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_example.h conf_test.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam3s
    ../../../../../../clock/sam3s/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../../boards/: board.h
