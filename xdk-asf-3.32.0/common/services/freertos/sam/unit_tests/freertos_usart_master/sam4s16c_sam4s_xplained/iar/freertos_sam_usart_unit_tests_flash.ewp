# IAR project freertos_sam_usart_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4S16C__; TEST_SUITE_DEFINE_ASSERT_MACRO; __FREERTOS__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../serial; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../gpio; ../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ..; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_usart_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_usart_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: timers.h semphr.h FreeRTOS.h StackMacros.h croutine.h queue.h mpu_wrappers.h FreeRTOS_CLI.h task.h projdefs.h list.h portable.h
  group common/services/freertos/sam
    ../../../../: freertos_usart_serial.c freertos_peripheral_control.c freertos_usart_serial.h freertos_peripheral_control_private.h freertos_peripheral_control.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master
    ../../: usart_unit_tests.c FreeRTOSConfig.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master/sam4s16c_sam4s_xplained
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_example.h conf_test.h
  group common/services/freertos/sam/unit_tests/freertos_usart_master/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group common/services/serial
    ../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../clock/sam4s/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/gpio
    ../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s8c.h sam4s4a.h sam4s4c.h sam4sd32b.h sam4s16b.h sam4sa16b.h sam4s2c.h sam4sa16c.h sam4s2a.h system_sam4s.h sam4sd16c.h sam4s8b.h sam4s.h sam4s4b.h sam4sd16b.h sam4sd32c.h sam4s16c.h sam4s2b.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_pio.h component_tc.h component_smc.h component_gpbr.h component_cmcc.h component_rtc.h component_dacc.h component_ssc.h component_rtt.h component_rstc.h component_uart.h component_chipid.h component_pwm.h component_pmc.h component_udp.h component_wdt.h component_crccu.h component_usart.h component_twi.h component_hsmci.h component_matrix.h component_pdc.h component_supc.h component_acc.h component_efc.h component_spi.h component_adc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4sd16b.h pio_sam4s2a.h pio_sam4sa16c.h pio_sam4s16c.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4s2b.h pio_sam4s8c.h pio_sam4sd32c.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s16b.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_cmcc.h instance_crccu.h instance_efc0.h instance_chipid.h instance_tc0.h instance_usart0.h instance_pmc.h instance_piob.h instance_twi0.h instance_hsmci.h instance_efc1.h instance_acc.h instance_spi.h instance_adc.h instance_ssc.h instance_tc1.h instance_pwm.h instance_udp.h instance_dacc.h instance_wdt.h instance_rtc.h instance_uart0.h instance_matrix.h instance_twi1.h instance_supc.h instance_uart1.h instance_rtt.h instance_usart1.h instance_gpbr.h instance_pioa.h instance_pioc.h instance_rstc.h instance_smc.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4s_xplained
    ../../../../../../../../sam/boards/sam4s_xplained/: init.c led.c sam4s_xplained.h led.h
