<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fifo_unit_tests.ewp</path>
	</project>
</workspace>
