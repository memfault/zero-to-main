<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\fifo_unit_tests_flash.ewp</path>
	</project>
</workspace>
