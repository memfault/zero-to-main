<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_example1_flash.ewp</path>
	</project>
</workspace>
