<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_example1.ewp</path>
	</project>
</workspace>
