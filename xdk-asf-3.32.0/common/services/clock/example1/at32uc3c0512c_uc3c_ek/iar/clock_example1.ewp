# IAR project clock_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/utils; ../../../../delay; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/boards/uc3c_ek; ../../../../../../avr32/drivers/scif; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../..; ../../../../../../avr32/boards; ..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/pm; ../../../../../utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock
    ../../../: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/uc3c
    ../../../uc3c/: osc.c sysclk.c pll.c sysclk.h pll.h genclk.h osc.h
  group common/services/clock/example1
    ../../: clock_example1.c
  group common/services/clock/example1/at32uc3c0512c_uc3c_ek
    ../: conf_clock.h conf_board.h
  group common/services/clock/example1/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3c.c scif_uc3c.h
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c sleep.h power_clocks_lib.h pm_uc3c.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3c_ek
    ../../../../../../avr32/boards/uc3c_ek/: led.c init.c led.h uc3c_ek.h
  group avr32/utils
    ../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
