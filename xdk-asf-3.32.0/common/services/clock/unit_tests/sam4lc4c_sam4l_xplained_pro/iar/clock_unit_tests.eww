<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_unit_tests_flash.ewp</path>
	</project>
</workspace>
