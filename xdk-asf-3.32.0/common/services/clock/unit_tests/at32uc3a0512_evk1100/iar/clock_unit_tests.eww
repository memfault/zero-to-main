<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_unit_tests.ewp</path>
	</project>
</workspace>
