<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_example2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\clock_example2_sram.ewp</path>
	</project>
</workspace>
