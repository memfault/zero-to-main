<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_example3_flash.ewp</path>
	</project>
</workspace>
