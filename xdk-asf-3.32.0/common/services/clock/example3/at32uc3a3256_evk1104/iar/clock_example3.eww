<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_example3.ewp</path>
	</project>
</workspace>
