# IAR project clock_example3.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: BOARD=XMEGA_A1U_XPLAINED_PRO; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../delay; ../../../../../../xmega/boards; ../../..; ..; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../ioport; ../../../../../../xmega/boards/xmega_a1u_xplained_pro; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_A1U_XPLAINED_PRO; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1U_XPLAINED_PRO; IOPORT_XMEGA_COMPAT
  group xmega/boards/xmega_a1u_xplained_pro
    ../../../../../../xmega/boards/xmega_a1u_xplained_pro/: board_init.c xmega_a1u_xplained_pro.h
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/xmega
    ../../../xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/clock/example3
    ../../: clock_example3_xmega.c
  group common/services/clock/example3/atxmega128a1u_xmega_a1u_xplained_pro
    ../: conf_clock.h conf_example3.h conf_board.h
  group common/services/clock/example3/atxmega128a1u_xmega_a1u_xplained_pro/iar
    ./: asf.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/xmega
    ../../../../delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
