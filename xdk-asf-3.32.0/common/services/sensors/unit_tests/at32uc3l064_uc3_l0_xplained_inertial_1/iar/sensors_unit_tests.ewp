# IAR project sensors_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3_L0_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/drivers/scif; ../../..; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/twim; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/eic; ../../../../serial; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../sleepmgr; ../../../../../utils; ../../../../../../avr32/boards/uc3_l0_xplained; ../../../../clock; ../../../../../utils/stdio/stdio_serial; ..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/drivers/flashcdw; ../../../../twi; ../../../../delay; ../../../../serial/uc3_usart; ../../../../../boards; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; ../../../module_config; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/sensors
    ../../../: sensor_bus.c sensor.c sensor_platform.c sensor_nvram.c sensor_dev.h sensor_bus.h sensor.h sensor_nvram.h
  group common/services/sensors/physics
    ../../../physics/: physics.c physics.h constants.h
  group common/services/sensors/drivers/invensense
    ../../../drivers/invensense/: imu3000.c itg3200.c itg3200.h imu3000.h
  group common/services/sensors/drivers/bosch
    ../../../drivers/bosch/: bma222.c bma250.c bma020.c bma180.c bma150.c bmp.c bma_axis.inc.c bma220.c bma222.h bma150.h bma250.h bma180.h bmp.h bma020.h bma220.h bma_axis.inc.h
  group common/services/sensors/drivers/kionix
    ../../../drivers/kionix/: kxtf9.c kxtf9.h
  group common/services/sensors/drivers/osram
    ../../../drivers/osram/: sfh5712.c sfh7770.c sfh7770.h sfh5712.h
  group common/services/sensors/drivers/honeywell
    ../../../drivers/honeywell/: hmc5883l.c hmc5883l.h
  group common/services/sensors/drivers/akm
    ../../../drivers/akm/: ak8975.c ak8975.h
  group common/services/sensors/unit_tests
    ../../: unit_tests.c
  group common/services/sensors/unit_tests/at32uc3l064_uc3_l0_xplained_inertial_1
    ../: conf_test.h conf_board.h conf_sleepmgr.h conf_usart_serial.h conf_twim.h
  group common/services/sensors/unit_tests/at32uc3l064_uc3_l0_xplained_inertial_1/iar
    ./: asf.h
  group common/services/sensors/module_config
    ../../../module_config/: conf_clock.h conf_platform.h conf_sensors.h
  group common/services/sensors/math
    ../../../math/: fixed.h fixed_t.h precision.h
  group common/services/sleepmgr
    ../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../clock/: genclk.h dfll.h osc.h sysclk.h
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c genclk.h sysclk.h osc.h dfll.h
  group common/services/serial
    ../../../../serial/: usart_serial.c serial.h
  group common/services/serial/uc3_usart
    ../../../../serial/uc3_usart/: usart_serial.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/twi
    ../../../../twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../twi/uc3_twim/: twi_master.h
  group common/boards
    ../../../../../boards/: board.h
  group common/boards/sensors_xplained
    ../../../../../boards/sensors_xplained/: sensors_xplained.c sensors_xplained.h xplained_headers.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c pm_uc3l.h sleep.h power_clocks_lib.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/twim
    ../../../../../../avr32/drivers/twim/: twim.c twim.h
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c usart.h
  group avr32/drivers/eic
    ../../../../../../avr32/drivers/eic/: eic.c eic.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c uc3_l0_xplained.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: mrepeat.h stringz.h preprocessor.h tpaste.h
