<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sensors_unit_tests.ewp</path>
	</project>
</workspace>
