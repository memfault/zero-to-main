# IAR project sensors_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT; BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/pmic; ../../..; ../../../../../../xmega/utils; ../../../../gpio; ../../../../serial; ../../../../../../xmega/utils/preprocessor; ../../../../serial/xmega_usart; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/drivers/nvm; ../../../../sleepmgr; ../../../../../utils; ../../../../clock; ../../../../../utils/stdio/stdio_serial; ../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../../xmega/boards; ../../../../twi; ..; ../../../../delay; ../../../../../../xmega/drivers/twi; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/drivers/sleep; ../../../module_config; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT; BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1
  XLINK.XclFile: lnk0t.xcl
  group common/services/sensors
    ../../../: sensor_bus.c sensor.c sensor_nvram.c sensor_platform.c sensor.h sensor_dev.h sensor_bus.h sensor_nvram.h
  group common/services/sensors/physics
    ../../../physics/: physics.c physics.h constants.h
  group common/services/sensors/unit_tests
    ../../: unit_tests.c
  group common/services/sensors/unit_tests/atxmega128a1_xmega_a1_xplained_inertial_1
    ../: conf_test.h conf_board.h conf_twim.h conf_sleepmgr.h conf_usart_serial.h
  group common/services/sensors/unit_tests/atxmega128a1_xmega_a1_xplained_inertial_1/iar
    ./: asf.h
  group common/services/sensors/drivers/bosch
    ../../../drivers/bosch/: bma222.c bma250.c bma020.c bma180.c bma150.c bmp.c bma_axis.inc.c bma220.c bma222.h bmp.h bma250.h bma150.h bma180.h bma020.h bma220.h bma_axis.inc.h
  group common/services/sensors/drivers/kionix
    ../../../drivers/kionix/: kxtf9.c kxtf9.h
  group common/services/sensors/drivers/osram
    ../../../drivers/osram/: sfh5712.c sfh7770.c sfh5712.h sfh7770.h
  group common/services/sensors/drivers/honeywell
    ../../../drivers/honeywell/: hmc5883l.c hmc5883l.h
  group common/services/sensors/drivers/invensense
    ../../../drivers/invensense/: itg3200.c imu3000.c itg3200.h imu3000.h
  group common/services/sensors/drivers/akm
    ../../../drivers/akm/: ak8975.c ak8975.h
  group common/services/sensors/module_config
    ../../../module_config/: conf_clock.h conf_platform.h conf_sensors.h
  group common/services/sensors/math
    ../../../math/: fixed.h fixed_t.h precision.h
  group common/services/sleepmgr
    ../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/serial
    ../../../../serial/: usart_serial.c serial.h
  group common/services/serial/xmega_usart
    ../../../../serial/xmega_usart/: usart_serial.h
  group common/services/twi
    ../../../../twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../twi/xmega_twi/: twi_master.h twi_slave.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/xmega
    ../../../../delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../../boards/: board.h
  group common/boards/sensors_xplained
    ../../../../../boards/sensors_xplained/: sensors_xplained.c sensors_xplained.h xplained_headers.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twis.c twim.c twi_common.h twis.h twim.h
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../../xmega/boards/xmega_a1_xplained/: init.c xmega_a1_xplained.h led.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h stringz.h mrepeat.h preprocessor.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
