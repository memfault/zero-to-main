<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wtk_example1_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\wtk_example1_sram.ewp</path>
	</project>
</workspace>
