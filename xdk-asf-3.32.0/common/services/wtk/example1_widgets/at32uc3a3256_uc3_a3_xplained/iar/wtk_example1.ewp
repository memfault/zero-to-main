# IAR project wtk_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/pdca; ../../../../../../avr32/drivers/twim; ../../../../gfx; ../../../../../utils/membag; ..; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../utils; ../../../../../../avr32/drivers/spi; ../../../../../components/touch/mxt; ../../../../clock; ../../..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../twi; ../../../../../../avr32/boards/uc3_a3_xplained; ../../../../delay; ../../../../../components/display/ili9341; ../../../../spi; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../ioport; ../../../../spi/uc3_spi; ../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/wtk
    ../../../: win.c wtk.c wtk_basic_frame.c wtk_button.c wtk_plot.c wtk_icon.c wtk_radio_button.c wtk_slider.c wtk_check_box.c wtk_label.c wtk_frame.c wtk_progress_bar.c win.h wtk_plot.h wtk.h wtk_button.h wtk_basic_frame.h wtk_check_box.h wtk_icon.h wtk_radio_button.h wtk_slider.h wtk_label.h wtk_frame.h wtk_progress_bar.h
  group common/services/wtk/example1_widgets
    ../../: example1.c widget_gui.c widget_gui.h conf_win.h conf_wtk.h conf_membag.h touch_interface.h conf_sysfont.h
  group common/services/wtk/example1_widgets/at32uc3a3256_uc3_a3_xplained
    ../: touch_interface.c conf_mxt.h conf_ili9341.h conf_clock.h conf_board.h conf_twim.h atmel_logo_small.h conf_spi_master.h
  group common/services/wtk/example1_widgets/at32uc3a3256_uc3_a3_xplained/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../clock/uc3a3_a4/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/spi
    ../../../../spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/gfx
    ../../../../gfx/: gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.h gfx_text.h gfx.h sysfont.h gfx_generic.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../ioport/uc3/: ioport.h
  group common/services/twi
    ../../../../twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../twi/uc3_twim/: twi_master.h
  group common/components/touch/mxt
    ../../../../../components/touch/mxt/: mxt_device.c mxt_device.h
  group common/components/display/ili9341
    ../../../../../components/display/ili9341/: ili9341.c ili9341.h ili9341_regs.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/membag
    ../../../../../utils/membag/: membag.c membag.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/twim
    ../../../../../../avr32/drivers/twim/: twim.c twim.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/pdca
    ../../../../../../avr32/drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_a3_xplained
    ../../../../../../avr32/boards/uc3_a3_xplained/: init.c led.c uc3_a3_xplained.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
