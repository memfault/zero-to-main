# IAR project wtk_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/pmic; ../..; ../../../../../../xmega/utils; ../../../../gfx; ../../../../../utils/membag; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../components/touch/mxt; ../../../../clock; ../../..; ../../../../../../xmega/boards; ../../../../gpio; ../../../../twi; ../../../../delay; ../../../../../components/display/ili9341; ..; ../../../../../../xmega/drivers/twi; ../../../../../../xmega/boards/xmega_c3_xplained; ../../../../spi; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/wtk
    ../../../: win.c wtk.c wtk_basic_frame.c wtk_plot.c wtk_icon.c wtk_radio_button.c wtk_slider.c wtk_button.c wtk_label.c wtk_frame.c wtk_progress_bar.c wtk_check_box.c wtk_button.h wtk_plot.h wtk.h wtk_check_box.h wtk_basic_frame.h wtk_radio_button.h wtk_label.h wtk_slider.h wtk_icon.h wtk_frame.h wtk_progress_bar.h win.h
  group common/services/wtk/example1_widgets
    ../../: example1.c widget_gui.c touch_interface.h conf_win.h widget_gui.h conf_wtk.h conf_membag.h conf_sysfont.h
  group common/services/wtk/example1_widgets/atxmega384c3_xmega_c3_xplained
    ../: touch_interface.c conf_usart_spi.h conf_mxt.h conf_board.h conf_ili9341.h conf_clock.h atmel_logo_small.h conf_twim.h
  group common/services/wtk/example1_widgets/atxmega384c3_xmega_c3_xplained/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h osc.h sysclk.h pll.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gfx
    ../../../../gfx/: gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.c gfx_text.c gfx_generic.h gfx.h gfx_ili9341_sdt028atft.h sysfont.h gfx_text.h
  group common/services/spi
    ../../../../spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/delay/xmega
    ../../../../delay/xmega/: cycle_counter.h
  group common/services/twi
    ../../../../twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../twi/xmega_twi/: twi_master.h twi_slave.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/components/touch/mxt
    ../../../../../components/touch/mxt/: mxt_device.c mxt_device.h
  group common/components/display/ili9341
    ../../../../../components/display/ili9341/: ili9341.c ili9341.h ili9341_regs.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/membag
    ../../../../../utils/membag/: membag.c membag.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twis.c twim.c twi_common.h twis.h twim.h
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_c3_xplained
    ../../../../../../xmega/boards/xmega_c3_xplained/: init.c led.h xmega_c3_xplained.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
