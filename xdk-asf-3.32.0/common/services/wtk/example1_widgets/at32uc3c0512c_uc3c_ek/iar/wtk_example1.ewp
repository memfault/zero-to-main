# IAR project wtk_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: GFX_INITIALIZED=1; CONF_GFX_HX8347A_ET024006DHU_EBI=1; BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../avr32/boards; ../..; ../../../../../../avr32/components/display/et024006dhu; ../../../../gfx; ../../../../../../avr32/boards/uc3c_ek; ../../../../../../avr32/components/touch/resistive_touch; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../utils; ../../../../clock; ../../..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../utils/membag; ../../../../../../avr32/drivers/adcifa; ../../../../delay; ../../../../../../avr32/drivers/ebi/smc; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../ioport; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/wtk
    ../../../: win.c wtk_button.c wtk.c wtk_basic_frame.c wtk_plot.c wtk_icon.c wtk_radio_button.c wtk_slider.c wtk_check_box.c wtk_label.c wtk_frame.c wtk_progress_bar.c win.h wtk_plot.h wtk.h wtk_button.h wtk_basic_frame.h wtk_check_box.h wtk_icon.h wtk_radio_button.h wtk_slider.h wtk_label.h wtk_frame.h wtk_progress_bar.h
  group common/services/wtk/example1_widgets
    ../../: example1.c widget_gui.c conf_win.h conf_wtk.h widget_gui.h conf_membag.h touch_interface.h conf_sysfont.h
  group common/services/wtk/example1_widgets/at32uc3c0512c_uc3c_ek
    ../: touch_interface.c conf_rtouch.h conf_ebi.h conf_clock.h conf_board.h conf_et024006dhu.h atmel_logo_small.h
  group common/services/wtk/example1_widgets/at32uc3c0512c_uc3c_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3c
    ../../../../clock/uc3c/: osc.c sysclk.c pll.c osc.h sysclk.h pll.h genclk.h
  group common/services/gfx
    ../../../../gfx/: gfx_hx8347a_et024006dhu_ebi.c sysfont.c gfx_generic.c gfx_text.c gfx_hx8347a_et024006dhu_ebi.h gfx.h sysfont.h gfx_generic.h gfx_text.h
  group common/services/delay
    ../../../../delay/: delay.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../ioport/uc3/: ioport.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/membag
    ../../../../../utils/membag/: membag.c membag.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82 intc.h
  group avr32/drivers/ebi/smc
    ../../../../../../avr32/drivers/ebi/smc/: smc.c smc.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/adcifa
    ../../../../../../avr32/drivers/adcifa/: adcifa.c adcifa.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/components/touch/resistive_touch
    ../../../../../../avr32/components/touch/resistive_touch/: rtouch.c rtouch.h
  group avr32/components/display/et024006dhu
    ../../../../../../avr32/components/display/et024006dhu/: et024006dhu.c smc_et024006dhu.h et024006dhu.h
  group avr32/boards/uc3c_ek
    ../../../../../../avr32/boards/uc3c_ek/: init.c led.c led.h uc3c_ek.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
