<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wtk_example3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\wtk_example3_sram.ewp</path>
	</project>
</workspace>
