<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wtk_example3.ewp</path>
	</project>
</workspace>
