<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wtk_training.ewp</path>
	</project>
</workspace>
