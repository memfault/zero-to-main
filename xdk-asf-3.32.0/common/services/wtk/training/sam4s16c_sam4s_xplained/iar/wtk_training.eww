<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wtk_training_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\wtk_training_sram.ewp</path>
	</project>
</workspace>
