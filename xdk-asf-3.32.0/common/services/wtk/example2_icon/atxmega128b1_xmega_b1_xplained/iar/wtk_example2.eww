<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wtk_example2.ewp</path>
	</project>
</workspace>
