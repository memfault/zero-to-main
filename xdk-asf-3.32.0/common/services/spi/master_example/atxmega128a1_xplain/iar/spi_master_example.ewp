# IAR project spi_master_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../..; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../../../xmega/drivers/spi; ../../../xmega_spi; ../../../../ioport; ..; ../../../../../../xmega/boards; ../../../../../utils; ../../../../../../xmega/boards/xplain; ../../../../gpio; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/spi
    ../../../: spi_master.h
  group common/services/spi/xmega_spi
    ../../../xmega_spi/: spi_master.c spi_master.h
  group common/services/spi/master_example
    ../../: spi_master_example.c
  group common/services/spi/master_example/atxmega128a1_xplain
    ../: conf_clock.h conf_spi_master_example.h conf_board.h conf_spi_master.h
  group common/services/spi/master_example/atxmega128a1_xplain/iar
    ./: asf.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
  group xmega/drivers/spi
    ../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c xplain.h led.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
