<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_master_example.ewp</path>
	</project>
</workspace>
