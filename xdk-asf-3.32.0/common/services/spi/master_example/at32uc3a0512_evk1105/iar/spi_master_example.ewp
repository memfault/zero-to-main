# IAR project spi_master_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../clock; ../../..; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ..; ../../../../../../avr32/boards; ../../../uc3_spi; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; ../../../../../../avr32/drivers/spi; ../../../../../../avr32/boards/evk1105; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/spi
    ../../../: spi_master.h
  group common/services/spi/uc3_spi
    ../../../uc3_spi/: spi_master.c spi_master.h
  group common/services/spi/master_example
    ../../: spi_master_example.c
  group common/services/spi/master_example/at32uc3a0512_evk1105
    ../: conf_clock.h conf_spi_master_example.h conf_board.h conf_spi_master.h
  group common/services/spi/master_example/at32uc3a0512_evk1105/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/uc3a0_a1
    ../../../../clock/uc3a0_a1/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../boards/: board.h
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/boards/evk1105
    ../../../../../../avr32/boards/evk1105/: init.c led.c evk1105.h led.h
  group avr32/utils
    ../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../avr32/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
