<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_master_example_flash.ewp</path>
	</project>
</workspace>
