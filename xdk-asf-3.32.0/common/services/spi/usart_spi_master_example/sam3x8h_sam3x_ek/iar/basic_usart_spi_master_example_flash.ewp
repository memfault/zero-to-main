# IAR project basic_usart_spi_master_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Atmel ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ..; ../../../sam_usart_spi; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/sam3x_ek; ../../../../../utils; ../../../../gpio; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/cmsis/sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: basic_usart_spi_master_example_flash.bin
  ILINK.IlinkOutputFile: basic_usart_spi_master_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8h.h sam3x8c.h sam3a8c.h sam3x8e.h sam3x4e.h sam3x4c.h sam3a4c.h sam3xa.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_piof.h instance_tc0.h instance_rstc.h instance_supc.h instance_adc.h instance_sdramc.h instance_piob.h instance_ssc.h instance_wdt.h instance_dacc.h instance_piod.h instance_spi0.h instance_pioa.h instance_usart1.h instance_matrix.h instance_usart3.h instance_smc.h instance_gpbr.h instance_hsmci.h instance_trng.h instance_efc0.h instance_emac.h instance_chipid.h instance_pioe.h instance_twi0.h instance_spi1.h instance_pwm.h instance_rtc.h instance_usart0.h instance_usart2.h instance_can0.h instance_twi1.h instance_uart.h instance_efc1.h instance_tc2.h instance_uotghs.h instance_tc1.h instance_rtt.h instance_pmc.h instance_dmac.h instance_can1.h instance_pioc.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../sam/utils/cmsis/sam3x/include/component/: component_ssc.h component_dmac.h component_gpbr.h component_rstc.h component_emac.h component_sdramc.h component_pmc.h component_usart.h component_dacc.h component_pwm.h component_hsmci.h component_pdc.h component_efc.h component_matrix.h component_pio.h component_adc.h component_uotghs.h component_can.h component_wdt.h component_uart.h component_rtt.h component_twi.h component_trng.h component_tc.h component_chipid.h component_rtc.h component_smc.h component_spi.h component_supc.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3a4c.h pio_sam3x4c.h pio_sam3x8e.h pio_sam3x8c.h pio_sam3x4e.h pio_sam3x8h.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3x_ek
    ../../../../../../sam/boards/sam3x_ek/: led.c init.c led.h sam3x_ek.h
  group common/services/spi
    ../../../: usart_spi.h
  group common/services/spi/sam_usart_spi
    ../../../sam_usart_spi/: usart_spi.c usart_spi.h
  group common/services/spi/usart_spi_master_example
    ../../: usart_spi_master_example.c
  group common/services/spi/usart_spi_master_example/sam3x8h_sam3x_ek
    ../: conf_usart_spi.h conf_clock.h conf_usart_spi_master_example.h conf_board.h
  group common/services/spi/usart_spi_master_example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3x
    ../../../../clock/sam3x/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
