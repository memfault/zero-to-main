<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\basic_usart_spi_master_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\basic_usart_spi_master_example_sram.ewp</path>
	</project>
</workspace>
