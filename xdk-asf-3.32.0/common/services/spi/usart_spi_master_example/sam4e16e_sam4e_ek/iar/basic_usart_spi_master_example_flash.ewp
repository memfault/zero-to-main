# IAR project basic_usart_spi_master_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../sam_usart_spi; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/fpu; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4e/source/templates; ..; ../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../utils; ../../../../../../sam/boards/sam4e_ek; ../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: basic_usart_spi_master_example_flash.bin
  ILINK.IlinkOutputFile: basic_usart_spi_master_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../sam/utils/cmsis/sam4e/include/: sam4e16cb.h sam4e.h sam4e8cb.h sam4e16c.h sam4e8e.h sam4e8c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../sam/utils/cmsis/sam4e/include/component/: rstc.h hsmci.h chipid.h pwm.h supc.h usart.h acc.h pmc.h tc.h smc.h rswdt.h afec.h rtc.h gmac.h can.h dacc.h spi.h aes.h twi.h efc.h pdc.h rtt.h matrix.h pio.h udp.h gpbr.h wdt.h uart.h cmcc.h dmac.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../sam/utils/cmsis/sam4e/include/instance/: pmc.h afec1.h rtc.h smc.h tc1.h uart0.h rstc.h wdt.h usart1.h piod.h rswdt.h gmac.h piob.h can0.h tc0.h chipid.h rtt.h dacc.h aes.h cmcc.h gpbr.h uart1.h pioe.h supc.h pioc.h efc.h can1.h twi0.h matrix.h hsmci.h dmac.h acc.h pioa.h pwm.h usart0.h twi1.h spi.h udp.h tc2.h afec0.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e8c.h sam4e8cb.h sam4e16c.h sam4e8e.h sam4e16e.h sam4e16cb.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/sam4e_ek
    ../../../../../../sam/boards/sam4e_ek/: init.c led.h sam4e_ek.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4e
    ../../../../clock/sam4e/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/spi
    ../../../: usart_spi.h
  group common/services/spi/sam_usart_spi
    ../../../sam_usart_spi/: usart_spi.c usart_spi.h
  group common/services/spi/usart_spi_master_example
    ../../: usart_spi_master_example.c
  group common/services/spi/usart_spi_master_example/sam4e16e_sam4e_ek
    ../: conf_usart_spi.h conf_clock.h conf_usart_spi_master_example.h conf_board.h
  group common/services/spi/usart_spi_master_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
