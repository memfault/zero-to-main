<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\basic_usart_spi_master_example.ewp</path>
	</project>
</workspace>
