# IAR project basic_usart_spi_master_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3S4C Atmel ATSAM3S4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/header_files; ../../../sam_usart_spi; ../../../../../../sam/utils; ../../../../../../sam/boards/sam3s_ek; ../../../../clock; ../../../../../../sam/boards; ../../..; ../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../boards; ..; ../../../../../../sam/utils/preprocessor; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../utils; ../../../../gpio; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/cmsis/sam3s/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: basic_usart_spi_master_example_flash.bin
  ILINK.IlinkOutputFile: basic_usart_spi_master_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../sam/utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c exceptions.h system_sam3s.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../../../../sam/utils/cmsis/sam3s/include/: sam3s4b.h sam3s1b.h sam3s2c.h sam3s2a.h sam3s1c.h sam3s4c.h sam3s.h sam3s4a.h sam3s2b.h sam3s1a.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../../../../sam/utils/cmsis/sam3s/include/instance/: instance_twi0.h instance_pmc.h instance_piob.h instance_adc.h instance_pioa.h instance_uart0.h instance_tc1.h instance_tc0.h instance_pwm.h instance_crccu.h instance_spi.h instance_chipid.h instance_rtt.h instance_ssc.h instance_usart0.h instance_rstc.h instance_matrix.h instance_supc.h instance_rtc.h instance_gpbr.h instance_wdt.h instance_acc.h instance_dacc.h instance_smc.h instance_udp.h instance_twi1.h instance_usart1.h instance_efc.h instance_pioc.h instance_hsmci.h instance_uart1.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../../../../sam/utils/cmsis/sam3s/include/pio/: pio_sam3s4c.h pio_sam3s2c.h pio_sam3s1b.h pio_sam3s4a.h pio_sam3s2a.h pio_sam3s4b.h pio_sam3s2b.h pio_sam3s1a.h pio_sam3s1c.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../../../../sam/utils/cmsis/sam3s/include/component/: component_smc.h component_ssc.h component_chipid.h component_twi.h component_pmc.h component_pwm.h component_wdt.h component_gpbr.h component_tc.h component_rtt.h component_spi.h component_crccu.h component_adc.h component_rtc.h component_udp.h component_usart.h component_matrix.h component_pdc.h component_acc.h component_rstc.h component_hsmci.h component_efc.h component_pio.h component_uart.h component_dacc.h component_supc.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3s_ek
    ../../../../../../sam/boards/sam3s_ek/: init.c led.c sam3s_ek.h led.h
  group common/services/spi
    ../../../: usart_spi.h
  group common/services/spi/sam_usart_spi
    ../../../sam_usart_spi/: usart_spi.c usart_spi.h
  group common/services/spi/usart_spi_master_example
    ../../: usart_spi_master_example.c
  group common/services/spi/usart_spi_master_example/sam3s4c_sam3s_ek
    ../: conf_usart_spi.h conf_clock.h conf_usart_spi_master_example.h conf_board.h
  group common/services/spi/usart_spi_master_example/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group common/services/clock
    ../../../../clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3s
    ../../../../clock/sam3s/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../boards/: board.h
