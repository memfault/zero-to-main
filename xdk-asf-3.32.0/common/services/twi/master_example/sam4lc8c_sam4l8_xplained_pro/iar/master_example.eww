<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\master_example_flash.ewp</path>
	</project>
</workspace>
