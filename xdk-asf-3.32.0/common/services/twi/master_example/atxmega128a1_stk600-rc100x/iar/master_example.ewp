# IAR project master_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/boards/stk600/rc100x; ..; ../../../../../../xmega/drivers/twi; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/utils; ../../../../../../xmega/utils/preprocessor; ../../../../gpio; ../../../../../../xmega/boards; ../../../../../utils; ../../..; ../..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group xmega/boards/stk600/rc100x
    ../../../../../../xmega/boards/stk600/rc100x/: init.c stk600_rc100x.h led.h
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twim.c twi_common.h twim.h
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/utils
    ../../../../../../xmega/utils/: compiler.h assembler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../xmega/utils/preprocessor/: tpaste.h stringz.h mrepeat.h preprocessor.h
  group xmega/utils/bit_handling
    ../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../xmega/utils/assembler/: iar.h
  group common/services/clock
    ../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/twi
    ../../../: twi_slave.h twi_master.h
  group common/services/twi/master_example
    ../../: twi_master_example.c
  group common/services/twi/master_example/atxmega128a1_stk600-rc100x
    ../: conf_clock.h conf_board.h conf_twim.h
  group common/services/twi/master_example/atxmega128a1_stk600-rc100x/iar
    ./: asf.h
  group common/services/twi/xmega_twi
    ../../../xmega_twi/: twi_master.h twi_slave.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
