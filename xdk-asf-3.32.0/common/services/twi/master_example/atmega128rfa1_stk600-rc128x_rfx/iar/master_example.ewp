# IAR project master_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../../mega/boards/stk600; ../../../../../../mega/drivers/cpu; ../../../../../../mega/utils; ../../../../clock; ../../..; ../../../../../boards; ..; ../../../../ioport; ../../../../../utils; ../../../../../../mega/boards/stk600/rc128x_rfx; ../../../../../../mega/drivers/twi; ../../../../gpio; ../..; ../../../../../../mega/utils/preprocessor; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group mega/drivers/twi
    ../../../../../../mega/drivers/twi/: twi_megarf.c twi_megarf.h
  group mega/drivers/cpu
    ../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/boards/stk600/rc128x_rfx
    ../../../../../../mega/boards/stk600/rc128x_rfx/: init.c stk600.h led.h
  group mega/utils
    ../../../../../../mega/utils/: status_codes.h assembler.h progmem.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../mega/utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group mega/utils/assembler
    ../../../../../../mega/utils/assembler/: iar.h
  group common/services/clock
    ../../../../clock/: sysclk.h
  group common/services/clock/mega
    ../../../../clock/mega/: sysclk.c sysclk.h
  group common/services/twi
    ../../../: twi_slave.h twi_master.h
  group common/services/twi/master_example
    ../../: twi_master_example.c
  group common/services/twi/master_example/atmega128rfa1_stk600-rc128x_rfx
    ../: conf_twi.h conf_board.h conf_clock.h
  group common/services/twi/master_example/atmega128rfa1_stk600-rc128x_rfx/iar
    ./: asf.h
  group common/services/twi/megarf_twi
    ../../../megarf_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../ioport/mega/: ioport.h
  group common/utils
    ../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../boards/: board.h
