<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\master_example.ewp</path>
	</project>
</workspace>
