# IAR project mxt143e_xplained_multi-touch_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; CONF_GFX_ILI9341_SDT028ATFT=1; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../services/spi/sam_spi; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../../../sam/utils/cmsis/sam4s/include; ../../../../services/gfx; ../../../../services/gpio; ../../../../../sam/drivers/spi; ../../../../../sam/drivers/pdc; ../../../../utils; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../../sam/boards; ../../../../services/delay; ..; ../../../../services/twi; ../..; ../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../components/display/ili9341; ../../../../../sam/utils; ../../../../services/spi; ../../../../../sam/utils/header_files; ../../../../boards; ../../../../services/ioport; ../../../../../sam/drivers/pio; ../../../../../sam/boards/sam4s_xplained; ../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mxt143e_xplained_multi-touch_demo_flash.bin
  ILINK.IlinkOutputFile: mxt143e_xplained_multi-touch_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam4s_xplained
    ../../../../../sam/boards/sam4s_xplained/: init.c led.c led.h sam4s_xplained.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pdc
    ../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/twi
    ../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../sam/utils/cmsis/sam4s/include/: sam4s2b.h sam4s2a.h sam4s.h sam4s8b.h sam4sd16c.h sam4sa16c.h sam4s16b.h sam4sd32b.h sam4s4c.h sam4s16c.h sam4sd32c.h sam4s2c.h sam4s4a.h sam4sd16b.h sam4s4b.h sam4s8c.h sam4sa16b.h system_sam4s.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../sam/utils/cmsis/sam4s/include/component/: component_adc.h component_cmcc.h component_ssc.h component_matrix.h component_efc.h component_pmc.h component_smc.h component_uart.h component_pio.h component_twi.h component_rtc.h component_acc.h component_wdt.h component_rstc.h component_supc.h component_spi.h component_dacc.h component_pdc.h component_tc.h component_pwm.h component_usart.h component_hsmci.h component_chipid.h component_crccu.h component_rtt.h component_gpbr.h component_udp.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_rtc.h instance_crccu.h instance_piob.h instance_twi0.h instance_usart0.h instance_gpbr.h instance_wdt.h instance_pwm.h instance_usart1.h instance_dacc.h instance_udp.h instance_adc.h instance_smc.h instance_uart0.h instance_chipid.h instance_rstc.h instance_uart1.h instance_acc.h instance_tc0.h instance_ssc.h instance_hsmci.h instance_efc0.h instance_rtt.h instance_efc1.h instance_spi.h instance_supc.h instance_pioc.h instance_tc1.h instance_pioa.h instance_twi1.h instance_pmc.h instance_matrix.h instance_cmcc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s2b.h pio_sam4s4c.h pio_sam4sd32c.h pio_sam4sa16c.h pio_sam4s16c.h pio_sam4sd16b.h pio_sam4s4b.h pio_sam4sd32b.h pio_sam4s8c.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s8b.h pio_sam4s4a.h pio_sam4s2c.h pio_sam4s2a.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group common/utils
    ../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c gfx_ili9341_sdt028atft.h gfx_generic.h gfx.h sysfont.h gfx_text.h
  group common/services/delay
    ../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam4s
    ../../../../services/clock/sam4s/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/spi
    ../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/services/twi
    ../../../../services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/applications/mxt143e_xplained_multi-touch_demo
    ../../: multi-touch_demo.c conf_sysfont.h
  group common/applications/mxt143e_xplained_multi-touch_demo/sam4s16c_sam4s_xplained
    ../: conf_twim.h conf_clock.h conf_board.h conf_mxt.h conf_spi_master.h conf_ili9341.h
  group common/applications/mxt143e_xplained_multi-touch_demo/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c ili9341_regs.h ili9341.h
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c mxt_device.h
  group common/boards
    ../../../../boards/: board.h
