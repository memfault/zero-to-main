<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mxt143e_xplained_multi-touch_demo_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\mxt143e_xplained_multi-touch_demo_sram.ewp</path>
	</project>
</workspace>
