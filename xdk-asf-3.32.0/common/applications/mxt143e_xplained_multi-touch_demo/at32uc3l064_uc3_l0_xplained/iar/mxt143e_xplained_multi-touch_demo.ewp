# IAR project mxt143e_xplained_multi-touch_demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../avr32/boards; ../../../../services/spi/uc3_spi; ../../../../../avr32/drivers/twim; ../../../../services/gfx; ../../../../../avr32/utils; ../../../../../avr32/drivers/gpio; ../../../../utils; ../../../../../avr32/drivers/spi; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../avr32/drivers/flashcdw; ../../../../services/twi; ../..; ../../../../services/delay; ../../../../components/display/ili9341; ../../../../services/spi; ../../../../boards; ../../../../services/ioport; ../../../../../avr32/drivers/pdca; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/boards/uc3_l0_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.h gfx_ili9341_sdt028atft.h sysfont.h gfx.h gfx_text.h
  group common/services/clock
    ../../../../services/clock/: dfll.h sysclk.h osc.h genclk.h
  group common/services/clock/uc3l
    ../../../../services/clock/uc3l/: dfll.c osc.c sysclk.c dfll.h osc.h genclk.h sysclk.h
  group common/services/spi
    ../../../../services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../services/ioport/uc3/: ioport.h
  group common/services/delay
    ../../../../services/delay/: delay.h
  group common/services/twi
    ../../../../services/twi/: twi_master.h
  group common/services/twi/uc3_twim
    ../../../../services/twi/uc3_twim/: twi_master.h
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c ili9341_regs.h ili9341.h
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c mxt_device.h
  group common/applications/mxt143e_xplained_multi-touch_demo
    ../../: multi-touch_demo.c conf_sysfont.h
  group common/applications/mxt143e_xplained_multi-touch_demo/at32uc3l064_uc3_l0_xplained
    ../: conf_mxt.h conf_spi_master.h conf_ili9341.h conf_clock.h conf_board.h conf_twim.h
  group common/applications/mxt143e_xplained_multi-touch_demo/at32uc3l064_uc3_l0_xplained/iar
    ./: asf.h
  group common/utils
    ../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../boards/: board.h
  group avr32/drivers/pdca
    ../../../../../avr32/drivers/pdca/: pdca.c pdca.h
  group avr32/drivers/twim
    ../../../../../avr32/drivers/twim/: twim.c twim.h
  group avr32/drivers/flashcdw
    ../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/spi
    ../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/uc3_l0_xplained
    ../../../../../avr32/boards/uc3_l0_xplained/: led.c init.c uc3_l0_xplained.h led.h
  group avr32/utils
    ../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../avr32/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
