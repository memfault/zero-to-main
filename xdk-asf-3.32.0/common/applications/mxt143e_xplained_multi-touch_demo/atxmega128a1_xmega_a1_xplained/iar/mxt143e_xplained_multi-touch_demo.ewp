# IAR project mxt143e_xplained_multi-touch_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x1000
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../services/delay; ../../../../components/display/ili9341; ../../../../services/gfx; ../../../../../xmega/drivers/pmic; ../../../../services/clock; ../../../../services/twi; ../../../../services/spi; ../../../../boards; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/utils; ../../../../../xmega/boards/xmega_a1_xplained; ../../../../services/ioport; ../../../../../xmega/drivers/usart; ../../../../../xmega/boards; ../../../../utils; ../../../../services/gpio; ../..; ../../../../../xmega/drivers/cpu; ../../../../components/touch/mxt; ../../../../../xmega/drivers/twi; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.h gfx.h gfx_ili9341_sdt028atft.h sysfont.h gfx_text.h
  group common/services/clock
    ../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../services/clock/xmega/: sysclk.c sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/spi
    ../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/twi
    ../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../services/twi/xmega_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../services/delay/xmega/: cycle_counter.h
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c ili9341_regs.h ili9341.h
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c mxt_device.h
  group common/applications/mxt143e_xplained_multi-touch_demo
    ../../: multi-touch_demo.c conf_sysfont.h
  group common/applications/mxt143e_xplained_multi-touch_demo/atxmega128a1_xmega_a1_xplained
    ../: conf_mxt.h conf_usart_spi.h conf_ili9341.h conf_board.h conf_twim.h conf_clock.h
  group common/applications/mxt143e_xplained_multi-touch_demo/atxmega128a1_xmega_a1_xplained/iar
    ./: asf.h
  group common/utils
    ../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../boards/: board.h
  group xmega/drivers/twi
    ../../../../../xmega/drivers/twi/: twim.c twis.c twim.h twis.h twi_common.h
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a1_xplained
    ../../../../../xmega/boards/xmega_a1_xplained/: init.c xmega_a1_xplained.h led.h
  group xmega/utils
    ../../../../../xmega/utils/: progmem.h status_codes.h compiler.h assembler.h
  group xmega/utils/bit_handling
    ../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/assembler
    ../../../../../xmega/utils/assembler/: iar.h
