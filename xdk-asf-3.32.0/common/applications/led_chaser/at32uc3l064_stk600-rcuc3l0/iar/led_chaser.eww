<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\led_chaser.ewp</path>
	</project>
</workspace>
