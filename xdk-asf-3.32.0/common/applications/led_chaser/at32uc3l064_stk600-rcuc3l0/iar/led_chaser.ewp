# IAR project led_chaser.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=STK600_RCUC3L0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/drivers/scif; ../../../../boards; ../../../../services/clock; ../../../../../avr32/boards; ../../../../../avr32/utils; ../../../../../avr32/drivers/gpio; ../../../../utils; ../../../../../avr32/drivers/pm; ../../../../../avr32/drivers/flashcdw; ../../../../../avr32/boards/stk600/rcuc3l0; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.IExtraOptions: --disable_inline_asm_label_replacement
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=STK600_RCUC3L0
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/stk600/rcuc3l0
    ../../../../../avr32/boards/stk600/rcuc3l0/: led.c init.c led.h stk600_rcuc3l0.h
  group avr32/drivers/scif
    ../../../../../avr32/drivers/scif/: scif_uc3l.c scif_uc3l.h
  group avr32/drivers/flashcdw
    ../../../../../avr32/drivers/flashcdw/: flashcdw.c flashcdw.h
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c pm_uc3l.h sleep.h power_clocks_lib.h
  group avr32/utils
    ../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../avr32/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group avr32/utils/header_files
    ../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/clock
    ../../../../services/clock/: dfll.h sysclk.h osc.h genclk.h
  group common/services/clock/uc3l
    ../../../../services/clock/uc3l/: dfll.c osc.c sysclk.c dfll.h osc.h genclk.h sysclk.h
  group common/applications/led_chaser
    ../../: led_example.c
  group common/applications/led_chaser/at32uc3l064_stk600-rcuc3l0
    ../: conf_clock.h conf_board.h conf_example.h
  group common/applications/led_chaser/at32uc3l064_stk600-rcuc3l0/iar
    ./: asf.h
  group common/utils
    ../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../boards/: board.h
