# IAR project led_chaser.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/boards/stk600/rc032x; ../../../../services/clock; ..; ../../../../services/gpio; ../../../../services/ioport; ../../../../boards; ../../../../../xmega/utils; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/boards; ../../../../utils; ../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  group common/applications/led_chaser
    ../../: led_example.c
  group common/applications/led_chaser/atxmega32e5_stk600-rc032x
    ../: conf_board.h conf_example.h conf_clock.h
  group common/applications/led_chaser/atxmega32e5_stk600-rc032x/iar
    ./: asf.h
  group common/services/ioport
    ../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/clock
    ../../../../services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../services/clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/gpio
    ../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/boards
    ../../../../boards/: board.h
  group common/utils
    ../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_avr8.h
  group xmega/boards/stk600/rc032x
    ../../../../../xmega/boards/stk600/rc032x/: init.c stk600_rc032x.h
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/utils
    ../../../../../xmega/utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/bit_handling
    ../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/assembler
    ../../../../../xmega/utils/assembler/: iar.h
