# IAR project mxt143e_xplained_calc_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../xmega/utils; ..; ../../../../services/gfx; ../..; ../../../../utils/membag; ../../../../services/ioport; ../../../../../xmega/drivers/usart; ../../../../../xmega/drivers/nvm; ../../../../utils; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../services/wtk; ../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../xmega/boards; ../../../../services/gpio; ../../../../services/twi; ../../../../services/delay; ../../../../components/display/ili9341; ../../../../../xmega/drivers/twi; ../../../../services/spi; ../../../../boards; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/wtk
    ../../../../services/wtk/: wtk_check_box.c wtk_button.c wtk_basic_frame.c win.c wtk_frame.c wtk_radio_button.c wtk_label.c wtk_progress_bar.c wtk_icon.c wtk_plot.c wtk.c wtk_slider.c wtk_button.h wtk_basic_frame.h wtk_check_box.h wtk_frame.h wtk_radio_button.h wtk_label.h wtk_progress_bar.h wtk_icon.h wtk.h wtk_plot.h wtk_slider.h win.h
  group common/services/clock
    ../../../../services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../../../services/clock/xmega/: sysclk.c sysclk.h pll.h osc.h
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_ili9341_sdt028atft.c sysfont.c gfx_text.c gfx_generic.h gfx_ili9341_sdt028atft.h sysfont.h gfx.h gfx_text.h
  group common/services/ioport
    ../../../../services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/spi
    ../../../../services/spi/: usart_spi.h
  group common/services/spi/xmega_usart_spi
    ../../../../services/spi/xmega_usart_spi/: usart_spi.c usart_spi.h
  group common/services/twi
    ../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/xmega_twi
    ../../../../services/twi/xmega_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../services/delay/xmega/: cycle_counter.h
  group common/applications/mxt143e_xplained_calculator_demo
    ../../: widget_gui.c calculator.c widget_gui.h conf_wtk.h conf_membag.h conf_win.h atmel_logo_small.h conf_sysfont.h
  group common/applications/mxt143e_xplained_calculator_demo/atxmega256a3bu_xmega_a3bu_xplained
    ../: conf_mxt.h conf_usart_spi.h conf_clock.h conf_ili9341.h conf_board.h conf_twim.h
  group common/applications/mxt143e_xplained_calculator_demo/atxmega256a3bu_xmega_a3bu_xplained/iar
    ./: asf.h
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c ili9341.h ili9341_regs.h
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c mxt_device.h
  group common/utils
    ../../../../utils/: parts.h interrupt.h
  group common/utils/membag
    ../../../../utils/membag/: membag.c membag.h
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../boards/: board.h
  group xmega/drivers/nvm
    ../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/twi
    ../../../../../xmega/drivers/twi/: twis.c twim.c twim.h twi_common.h twis.h
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/pmic
    ../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../xmega/utils/: compiler.h progmem.h status_codes.h assembler.h
  group xmega/utils/bit_handling
    ../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../xmega/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group xmega/utils/assembler
    ../../../../../xmega/utils/assembler/: iar.h
