<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
