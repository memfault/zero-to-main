<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_quick_start_dma_flash.ewp</path>
	</project>
</workspace>
