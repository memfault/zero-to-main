<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_quick_start_flash.ewp</path>
	</project>
</workspace>
