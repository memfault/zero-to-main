<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_unit_test_flash.ewp</path>
	</project>
</workspace>
