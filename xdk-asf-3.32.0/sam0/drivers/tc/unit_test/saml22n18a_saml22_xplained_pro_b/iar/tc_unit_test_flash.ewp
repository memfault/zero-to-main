# IAR project tc_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO_B; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; _ASSERT_ENABLE_; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../system/power; ../../../../system/reset; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/saml22/include; ../../../../../utils; ../../../../extint/extint_sam_l_c; ../../../../port; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../events/events_sam_l_c; ../..; ../../../tc_sam_l_c; ../../../../../utils/cmsis/saml22/source; ../../../../system/interrupt; ../../../../system/power/power_sam_l; ../../..; ../../../../../boards/saml22_xplained_pro_b; ..; ../../../../../../common/utils; ../../../../sercom; ../../../../system/clock/clock_saml22; ../../../../../../common/boards; ../../../../system/reset/reset_sam_l; ../../../../system/pinmux; ../../../../system; ../../../../extint; ../../../../events; ../../../../../utils/header_files; ../../../../system/interrupt/system_interrupt_saml22; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tc_unit_test_flash.bin
  ILINK.IlinkOutputFile: tc_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../system/clock/clock_saml22/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../extint/extint_sam_l_c/: extint.c
  group sam0/drivers/tc
    ../../../: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/unit_test
    ../../: unit_test.c
  group sam0/drivers/tc/unit_test/saml22n18a_saml22_xplained_pro_b
    ../: conf_clocks.h conf_board.h conf_test.h conf_extint.h
  group sam0/drivers/tc/unit_test/saml22n18a_saml22_xplained_pro_b/iar
    ./: asf.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../tc_sam_l_c/: tc.c
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../events/events_sam_l_c/: events.c
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../utils/cmsis/saml22/include/: saml22g16a.h saml22j18a.h saml22g18a.h saml22.h saml22j16a.h saml22n18a.h saml22n17a.h saml22n16a.h saml22g17a.h saml22j17a.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../utils/cmsis/saml22/include/component/: adc.h supc.h rtc.h port.h tc.h mclk.h evsys.h eic.h pac.h rstc.h usb.h ac.h pm.h wdt.h tal.h sercom.h trng.h freqm.h oscctrl.h gclk.h osc32kctrl.h ccl.h mtb.h dsu.h tcc.h aes.h dmac.h nvmctrl.h slcd.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../utils/cmsis/saml22/include/instance/: pac.h evsys.h pm.h supc.h aes.h dsu.h tc0.h sercom3.h sercom1.h tc3.h rtc.h mclk.h sercom5.h slcd.h eic.h tc1.h ccl.h sercom0.h nvmctrl.h usb.h rstc.h tc2.h osc32kctrl.h tcc0.h sercom4.h sercom2.h gclk.h dmac.h freqm.h trng.h wdt.h ac.h tal.h adc.h oscctrl.h mtb.h port.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../utils/cmsis/saml22/include/pio/: saml22j17a.h saml22g16a.h saml22j16a.h saml22n16a.h saml22j18a.h saml22n17a.h saml22g18a.h saml22g17a.h saml22n18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
