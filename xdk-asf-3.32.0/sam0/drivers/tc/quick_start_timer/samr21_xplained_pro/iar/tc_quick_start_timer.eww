<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tc_quick_start_timer_flash.ewp</path>
	</project>
</workspace>
