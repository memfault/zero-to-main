<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\opamp_quick_start_flash.ewp</path>
	</project>
</workspace>
