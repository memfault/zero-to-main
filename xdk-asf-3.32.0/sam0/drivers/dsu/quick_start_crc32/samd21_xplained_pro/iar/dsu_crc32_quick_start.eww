<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dsu_crc32_quick_start_flash.ewp</path>
	</project>
</workspace>
