<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\i2s_quick_start_dma_flash.ewp</path>
	</project>
</workspace>
