<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt_unit_test_flash.ewp</path>
	</project>
</workspace>
