<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\wdt_quick_start_flash.ewp</path>
	</project>
</workspace>
