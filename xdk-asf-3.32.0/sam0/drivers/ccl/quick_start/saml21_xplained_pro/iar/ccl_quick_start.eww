<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ccl_quick_start_flash.ewp</path>
	</project>
</workspace>
