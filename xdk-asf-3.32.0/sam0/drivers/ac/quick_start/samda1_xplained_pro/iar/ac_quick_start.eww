<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ac_quick_start_flash.ewp</path>
	</project>
</workspace>
