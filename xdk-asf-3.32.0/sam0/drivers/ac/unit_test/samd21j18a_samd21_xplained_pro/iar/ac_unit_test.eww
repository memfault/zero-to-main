<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ac_unit_test_flash.ewp</path>
	</project>
</workspace>
