<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\port_quick_start_flash.ewp</path>
	</project>
</workspace>
