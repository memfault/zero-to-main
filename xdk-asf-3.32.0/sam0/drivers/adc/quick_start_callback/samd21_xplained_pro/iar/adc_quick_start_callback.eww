<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
