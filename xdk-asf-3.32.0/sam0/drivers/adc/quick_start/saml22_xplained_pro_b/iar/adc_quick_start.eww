<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_quick_start_flash.ewp</path>
	</project>
</workspace>
