# IAR project adc_quick_start_dma_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=false; ARM_MATH_CM0PLUS=true; DAC_CALLBACK_MODE=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../..; ../../../../port; ../../../../system/reset; ../../..; ../../../../dac; ../../../../../utils/preprocessor; ../../../../dma; ../../../../system/clock/clock_samd09_d10_d11; ../../../../../utils; ../../../../../boards/samd11_xplained_pro; ../../../../system/power; ../../../../../boards; ../../../adc_sam_d_r; ../../../../system/reset/reset_sam_d_r; ../../../../dac/dac_sam_d_c; ../../../../../../common/utils; ../../../../../utils/cmsis/samd11/source; ../../../../system/interrupt; ../../../../system/power/power_sam_d_r; ../../../../system/interrupt/system_interrupt_samd10_d11; ../../../../../utils/cmsis/samd11/include; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../../../../../utils/header_files; ..; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_quick_start_dma_flash.bin
  ILINK.IlinkOutputFile: adc_quick_start_dma_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd09_d10_d11
    ../../../../system/clock/clock_samd09_d10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/adc
    ../../../: adc.h
  group sam0/drivers/adc/adc_sam_d_r
    ../../../adc_sam_d_r/: adc.c adc_feature.h
  group sam0/drivers/adc/quick_start_dma
    ../../: qs_adc_dma_use.c qs_adc_dma_use.h
  group sam0/drivers/adc/quick_start_dma/samd11_xplained_pro
    ../: conf_board.h conf_dma.h conf_clocks.h
  group sam0/drivers/adc/quick_start_dma/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/dac
    ../../../../dac/: dac.h dac_callback.h
  group sam0/drivers/dac/dac_sam_d_c
    ../../../../dac/dac_sam_d_c/: dac.c dac_callback.c dac_feature.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/dma
    ../../../../dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../dma/quick_start/: qs_dma_basic.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../utils/cmsis/samd11/include/: samd11d14as.h samd11d14am.h samd11d14au.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../utils/cmsis/samd11/include/instance/: eic.h sercom1.h dmac.h rtc.h adc.h pac0.h gclk.h sercom0.h tc1.h tcc0.h tc2.h sercom2.h wdt.h port.h ac.h pac1.h usb.h nvmctrl.h dsu.h pm.h mtb.h sysctrl.h pac2.h sbmatrix.h evsys.h dac.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../utils/cmsis/samd11/include/component/: hmatrixb.h adc.h sysctrl.h pm.h dmac.h pac.h wdt.h rtc.h gclk.h dsu.h evsys.h nvmctrl.h usb.h ac.h port.h mtb.h tc.h sercom.h eic.h tcc.h dac.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../utils/cmsis/samd11/include/pio/: samd11d14au.h samd11d14am.h samd11c14a.h samd11d14as.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
