<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_unit_test_flash.ewp</path>
	</project>
</workspace>
