<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\divas_quick_start_flash.ewp</path>
	</project>
</workspace>
