<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tcc_quick_start_buffering_flash.ewp</path>
	</project>
</workspace>
