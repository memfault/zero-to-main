# IAR project tcc_quick_start_faultn_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TCC_ASYNC=true; EVENTS_INTERRUPT_HOOKS_MODE=true; EXTINT_CALLBACK_MODE=true; BOARD=SAMC21_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; __SAMC21J18A__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samc21/include; ../../../../system/power; ../../../../system/reset; ../../../../../utils/cmsis/samc21/source; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../extint/extint_sam_l_c; ../../../../port; ../../../../../boards; ../../../../system/interrupt/system_interrupt_samc20_c21; ../../../../events/events_sam_l_c; ../../../../../../common/utils; ../../../../system/interrupt; ../../../../system/power/power_sam_c; ../..; ../../../../system/clock/clock_samc20_c21; ../../../../system/reset/reset_sam_c; ../../..; ../../../../../../common/boards; ../../../../system/pinmux; ..; ../../../../system; ../../../../extint; ../../../../events; ../../../../../utils/header_files; ../../../../../boards/samc21_xplained_pro; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tcc_quick_start_faultn_flash.bin
  ILINK.IlinkOutputFile: tcc_quick_start_faultn_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../system/clock/clock_samc20_c21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../system/reset/reset_sam_c/: reset.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../system/power/power_sam_c/: power.h
  group sam0/drivers/tcc
    ../../../: tcc.c tcc_callback.c tcc_callback.h tcc.h
  group sam0/drivers/tcc/quick_start_faultn
    ../../: qs_tcc_faultn.c qs_tcc_faultn.h
  group sam0/drivers/tcc/quick_start_faultn/samc21_xplained_pro
    ../: conf_board.h conf_quick_start_faultn.h conf_clocks.h conf_extint.h
  group sam0/drivers/tcc/quick_start_faultn/samc21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/tcc/quick_start_timer
    ../../../quick_start_timer/: qs_tcc_timer.h
  group sam0/drivers/tcc/quick_start_callback
    ../../../quick_start_callback/: qs_tcc_callback.h
  group sam0/drivers/tcc/quick_start_buffering
    ../../../quick_start_buffering/: qs_tcc_buffering.h
  group sam0/drivers/tcc/quick_start_faultx
    ../../../quick_start_faultx/: qs_tcc_faultx.h
  group sam0/drivers/tcc/quick_start_dma
    ../../../quick_start_dma/: qs_tcc_dma.h
  group sam0/drivers/tcc/quick_start
    ../../../quick_start/: qs_tcc_basic.h
  group sam0/drivers/extint
    ../../../../extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../extint/extint_sam_l_c/: extint.c
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_common.h events_hooks.h events.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../events/events_sam_l_c/: events.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samc21_xplained_pro
    ../../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../utils/cmsis/samc21/include/: samc21g15a.h samc21g17a.h samc21.h samc21e15a.h samc21j18a.h samc21g18a.h samc21e16a.h samc21e18a.h samc21g16a.h samc21j17a.h samc21e17a.h samc21j15a.h samc21j16a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../utils/cmsis/samc21/include/instance/: pm.h wdt.h dmac.h tcc0.h adc1.h rstc.h sercom2.h supc.h can1.h sercom0.h tsens.h evsys.h eic.h gclk.h dsu.h tc0.h tal.h nvmctrl.h oscctrl.h tc3.h tcc1.h port.h freqm.h dac.h divas.h osc32kctrl.h pac.h tc2.h mclk.h mtb.h ac.h sercom5.h tc4.h ccl.h sercom3.h can0.h sercom1.h adc0.h tcc2.h sercom4.h tc1.h sdadc.h rtc.h hmatrixhs.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../utils/cmsis/samc21/include/component/: gclk.h tc.h evsys.h ccl.h pac.h divas.h rstc.h tal.h supc.h nvmctrl.h adc.h tsens.h sdadc.h tcc.h mtb.h port.h osc32kctrl.h sercom.h freqm.h dsu.h dac.h ac.h mclk.h eic.h wdt.h can.h oscctrl.h dmac.h rtc.h hmatrixb.h pm.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../utils/cmsis/samc21/include/pio/: samc21j18a.h samc21j15a.h samc21j17a.h samc21e15a.h samc21e16a.h samc21g16a.h samc21g17a.h samc21g15a.h samc21e18a.h samc21j16a.h samc21e17a.h samc21g18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
