# IAR project tcc_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TCC_ASYNC=true; EVENTS_INTERRUPT_HOOKS_MODE=true; USART_CALLBACK_MODE=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAML21J18A__; _ASSERT_ENABLE_; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../system/power; ../../../../system/reset; ../../../../system/interrupt/system_interrupt_saml21; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../extint/extint_sam_l_c; ../../../../port; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../events/events_sam_l_c; ../../../../../../common/utils; ../..; ../../../../system/interrupt; ../../../../system/power/power_sam_l; ../../../../../utils/header_files; ..; ../../../../../boards/saml21_xplained_pro; ../../../../sercom; ../../../../../utils/cmsis/saml21/include; ../../../../system/clock/clock_saml21; ../../../../../../common/boards; ../../../../system/reset/reset_sam_l; ../../../../system/pinmux; ../../..; ../../../../system; ../../../../extint; ../../../../events; ../../../../../utils/cmsis/saml21/source; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tcc_unit_test_flash.bin
  ILINK.IlinkOutputFile: tcc_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/tcc
    ../../../: tcc.c tcc_callback.c tcc_callback.h tcc.h
  group sam0/drivers/tcc/unit_test
    ../../: unit_test.c
  group sam0/drivers/tcc/unit_test/saml21j18a_saml21_xplained_pro
    ../: conf_clocks.h conf_board.h conf_test.h conf_extint.h
  group sam0/drivers/tcc/unit_test/saml21j18a_saml21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/tcc/quick_start_callback
    ../../../quick_start_callback/: qs_tcc_callback.h
  group sam0/drivers/tcc/quick_start_faultx
    ../../../quick_start_faultx/: qs_tcc_faultx.h
  group sam0/drivers/tcc/quick_start_dma
    ../../../quick_start_dma/: qs_tcc_dma.h
  group sam0/drivers/tcc/quick_start_buffering
    ../../../quick_start_buffering/: qs_tcc_buffering.h
  group sam0/drivers/tcc/quick_start_timer
    ../../../quick_start_timer/: qs_tcc_timer.h
  group sam0/drivers/tcc/quick_start_faultn
    ../../../quick_start_faultn/: qs_tcc_faultn.h
  group sam0/drivers/tcc/quick_start
    ../../../quick_start/: qs_tcc_basic.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/extint
    ../../../../extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_common.h events_hooks.h events.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../events/events_sam_l_c/: events.c
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../utils/cmsis/saml21/include/: saml21g18a.h saml21e18a.h saml21j18a.h saml21.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../utils/cmsis/saml21/include/pio/: saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../utils/cmsis/saml21/include/component/: oscctrl.h adc_100.h sercom.h wdt.h ccl.h ac.h nvmctrl_301.h rstc_100.h opamp.h usb.h pm_100.h dmac.h gclk_100.h port.h eic_100.h aes.h pac_100.h rtc_100.h evsys.h tcc_200.h tal.h dsu.h osc32kctrl.h tc_100.h supc_100.h mclk_100.h trng.h dac.h mtb.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../utils/cmsis/saml21/include/instance/: trng.h mclk_100.h ccl.h rtc_100.h sercom2.h tc1_100.h wdt.h sercom0.h mtb.h opamp.h sercom4.h port.h gclk_100.h sercom1.h pac_100.h ac.h oscctrl.h evsys.h tc0_100.h sercom5.h tc3_100.h sercom3.h tc4_100.h tal.h eic_100.h adc_100.h nvmctrl_301.h pm_100.h aes.h dsu.h tcc1_200.h tcc0_200.h tcc2_200.h osc32kctrl.h usb.h supc_100.h dac.h rstc_100.h dmac.h tc2_100.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrepeat.h stringz.h mrecursion.h preprocessor.h tpaste.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
