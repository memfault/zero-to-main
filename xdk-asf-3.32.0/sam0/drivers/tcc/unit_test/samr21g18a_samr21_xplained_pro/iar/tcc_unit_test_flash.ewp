# IAR project tcc_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAMR21_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; EXTINT_CALLBACK_MODE=true; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; _ASSERT_ENABLE_; TCC_ASYNC=true
  ICCARM.CCIncludePath2: ../../../../port; ../../../../system/reset; ../../../../system/interrupt/system_interrupt_samr21; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/samr21/source; ../../../../../utils; ../../../../sercom; ../../../../system/power; ../../../../../boards; ../../../../sercom/usart; ../../../../../../common/services/serial; ../../../../../../common/utils; ../../../../extint/extint_sam_d_r; ../..; ../../../../system/interrupt; ..; ../../../../system/power/power_sam_d_r; ../../../../system/reset/reset_sam_d_r; ../../../../../boards/samr21_xplained_pro; ../../../../../utils/cmsis/samr21/include; ../../../../events/events_sam_d_r; ../../..; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../../../../extint; ../../../../events; ../../../../../utils/header_files; ../../../../system/clock/clock_samd21_r21_da; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tcc_unit_test_flash.bin
  ILINK.IlinkOutputFile: tcc_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../utils/cmsis/samr21/include/: samr21g17a.h samr21e17a.h samr21e16a.h samr21e18a.h samr21.h samr21e19a.h samr21g16a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../utils/cmsis/samr21/include/pio/: samr21e19a.h samr21e16a.h samr21e17a.h samr21e18a.h samr21g17a.h samr21g16a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../utils/cmsis/samr21/include/instance/: port.h nvmctrl.h tc3.h sysctrl.h sercom0.h tcc1.h wdt.h gclk.h evsys.h pac2.h mtb.h pac0.h sercom4.h rtc.h pac1.h sercom2.h rfctrl.h eic.h tcc2.h ac.h sbmatrix.h tcc0.h tc4.h sercom3.h sercom5.h usb.h tc5.h dmac.h adc.h sercom1.h pm.h dsu.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../utils/cmsis/samr21/include/component/: eic.h evsys.h adc.h hmatrixb.h mtb.h rfctrl.h gclk.h tcc.h ac.h pm.h dmac.h rtc.h pac.h dsu.h port.h wdt.h nvmctrl.h sysctrl.h usb.h tc.h sercom.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/tcc
    ../../../: tcc.c tcc_callback.c tcc_callback.h tcc.h
  group sam0/drivers/tcc/unit_test
    ../../: unit_test.c
  group sam0/drivers/tcc/unit_test/samr21g18a_samr21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group sam0/drivers/tcc/unit_test/samr21g18a_samr21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/tcc/quick_start_timer
    ../../../quick_start_timer/: qs_tcc_timer.h
  group sam0/drivers/tcc/quick_start_callback
    ../../../quick_start_callback/: qs_tcc_callback.h
  group sam0/drivers/tcc/quick_start_buffering
    ../../../quick_start_buffering/: qs_tcc_buffering.h
  group sam0/drivers/tcc/quick_start_faultx
    ../../../quick_start_faultx/: qs_tcc_faultx.h
  group sam0/drivers/tcc/quick_start_dma
    ../../../quick_start_dma/: qs_tcc_dma.h
  group sam0/drivers/tcc/quick_start_faultn
    ../../../quick_start_faultn/: qs_tcc_faultn.h
  group sam0/drivers/tcc/quick_start
    ../../../quick_start/: qs_tcc_basic.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../system/clock/clock_samd21_r21_da/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_d_r
    ../../../../events/events_sam_d_r/: events.c
  group sam0/drivers/sercom
    ../../../../sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/extint
    ../../../../extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r
    ../../../../extint/extint_sam_d_r/: extint.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
