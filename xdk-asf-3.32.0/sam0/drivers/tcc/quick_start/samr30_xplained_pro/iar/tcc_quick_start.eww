<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tcc_quick_start_flash.ewp</path>
	</project>
</workspace>
