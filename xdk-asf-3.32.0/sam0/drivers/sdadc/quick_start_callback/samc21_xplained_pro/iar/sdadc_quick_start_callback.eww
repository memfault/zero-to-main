<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sdadc_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
