<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sdadc_quick_start_flash.ewp</path>
	</project>
</workspace>
