<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_quick_start_dma_flash.ewp</path>
	</project>
</workspace>
