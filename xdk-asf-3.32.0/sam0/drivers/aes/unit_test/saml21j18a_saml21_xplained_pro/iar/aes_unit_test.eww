<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_unit_test_flash.ewp</path>
	</project>
</workspace>
