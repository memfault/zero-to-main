<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\aes_quick_start_polled_flash.ewp</path>
	</project>
</workspace>
