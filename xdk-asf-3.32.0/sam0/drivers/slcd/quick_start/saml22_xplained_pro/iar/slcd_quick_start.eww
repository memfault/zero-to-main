<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\slcd_quick_start_flash.ewp</path>
	</project>
</workspace>
