<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pinmux_quick_start_flash.ewp</path>
	</project>
</workspace>
