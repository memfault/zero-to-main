<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_quick_start_gclk_flash.ewp</path>
	</project>
</workspace>
