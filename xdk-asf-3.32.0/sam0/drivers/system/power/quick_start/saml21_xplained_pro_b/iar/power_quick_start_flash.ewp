# IAR project power_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; EXTINT_CALLBACK_MODE=true; __SAML21J18B__; CYCLE_MODE; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../..; ../../../../reset; ../../../../../../utils/preprocessor; ../../../../../../boards/saml21_xplained_pro_b; ../../../../../../../common2/services/delay; ../../../../../../utils; ..; ../..; ../../../../../extint/extint_sam_l_c; ../../../../../port; ../../../../../../boards; ../../../../../../utils/cmsis/saml21/include_b; ../../../../../../../common/utils; ../../../../interrupt; ../../../power_sam_l; ../../../../../../utils/header_files; ../../../../interrupt/system_interrupt_saml21; ../../../../../../../common2/services/delay/sam0; ../../../../clock/clock_saml21; ../../../../../../../common/boards; ../../../../reset/reset_sam_l; ../../../../pinmux; ../../../..; ../../../../../extint; ../../../../../../utils/cmsis/saml21/source; ../../../../clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: power_quick_start_flash.bin
  ILINK.IlinkOutputFile: power_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/quick_start
    ../../: qs_power.c
  group sam0/drivers/system/power/quick_start/saml21_xplained_pro_b
    ../: conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group sam0/drivers/system/power/quick_start/saml21_xplained_pro_b/iar
    ./: asf.h
  group sam0/drivers/system/power/power_sam_l
    ../../../power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../utils/cmsis/saml21/include_b/: saml21e15b.h saml21g16b.h saml21.h saml21j17b.h saml21j16b.h saml21j18b.h saml21e17b.h saml21g17b.h saml21g18b.h saml21e18b.h saml21e16b.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../utils/cmsis/saml21/include_b/pio/: saml21e15b.h saml21g17b.h saml21e17b.h saml21g18b.h saml21e16b.h saml21g16b.h saml21j17b.h saml21e18b.h saml21j18b.h saml21j16b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../utils/cmsis/saml21/include_b/instance/: trng.h tcc2.h tcc0.h dsu.h tc2.h tal.h mtb.h ac.h evsys.h rtc.h tc4.h sercom0.h sercom2.h eic.h oscctrl.h tc3.h port.h opamp.h tc1.h sercom4.h sercom3.h wdt.h nvmctrl.h mclk.h aes.h pac.h rstc.h sercom1.h dmac.h supc.h ccl.h tc0.h dac.h sercom5.h adc.h osc32kctrl.h gclk.h pm.h tcc1.h usb.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../utils/cmsis/saml21/include_b/component/: trng.h oscctrl.h supc.h tc.h sercom.h rstc.h dmac.h rtc.h aes.h evsys.h gclk.h mclk.h dsu.h tcc.h dac.h eic.h mtb.h pm.h opamp.h port.h usb.h osc32kctrl.h adc.h wdt.h pac.h ccl.h tal.h nvmctrl.h ac.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
