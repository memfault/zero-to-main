# IAR project power_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; ARM_MATH_CM0PLUS=true; EXTINT_CALLBACK_MODE=true; BOARD=SAMR30_XPLAINED_PRO; CYCLE_MODE
  ICCARM.CCIncludePath2: ../../..; ../../../../../../utils/cmsis/samr30/source; ../../../../../../utils/preprocessor; ../../../../../../../common2/services/delay; ../../../../../../utils; ../..; ../../../../../extint/extint_sam_l_c; ../../../../../port; ../../../../../../boards; ../../../../reset; ../../../../../../../common/utils; ../../../../../../boards/samr30_xplained_pro; ../../../../interrupt; ../../../power_sam_l; ../../../../interrupt/system_interrupt_samr30; ../../../../../../utils/cmsis/samr30/include; ../../../../../../../common2/services/delay/sam0; ..; ../../../../../../../common/boards; ../../../../reset/reset_sam_l; ../../../../pinmux; ../../../..; ../../../../../extint; ../../../../clock/clock_samr30; ../../../../../../utils/header_files; ../../../../clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: power_quick_start_flash.bin
  ILINK.IlinkOutputFile: power_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/clock
    ../../../../clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../clock/clock_samr30/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/quick_start
    ../../: qs_power.c
  group sam0/drivers/system/power/quick_start/samr30_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group sam0/drivers/system/power/quick_start/samr30_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/power/power_sam_l
    ../../../power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../utils/cmsis/samr30/include/: samr30e18a.h samr30.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../utils/cmsis/samr30/include/instance/: tc0.h usb.h evsys.h sercom0.h tcc1.h nvmctrl.h rstc.h tc4.h sercom3.h rfctrl.h ccl.h rtc.h ac.h port.h sercom5.h wdt.h sercom2.h tal.h pac.h osc32kctrl.h mtb.h sercom4.h mclk.h gclk.h tcc0.h adc.h tcc2.h tc1.h eic.h sercom1.h dmac.h oscctrl.h pm.h dsu.h supc.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../utils/cmsis/samr30/include/component/: nvmctrl.h mclk.h dmac.h usb.h osc32kctrl.h rstc.h evsys.h dsu.h ac.h supc.h port.h ccl.h pac.h mtb.h gclk.h eic.h adc.h rfctrl.h tal.h tc.h wdt.h sercom.h pm.h rtc.h oscctrl.h tcc.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
