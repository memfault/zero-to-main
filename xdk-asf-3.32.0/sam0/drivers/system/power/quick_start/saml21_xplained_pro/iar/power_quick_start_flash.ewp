# IAR project power_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; EXTINT_CALLBACK_MODE=true; __SAML21J18A__; CYCLE_MODE; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../..; ../../../../reset; ../../../../../../boards/saml21_xplained_pro; ../../../../../../utils/preprocessor; ../../../../../../../common2/services/delay; ../../../../../../utils; ../..; ../../../../../extint/extint_sam_l_c; ../../../../../port; ../../../../../../boards; ../../../../../../../common/utils; ../../../../interrupt; ../../../power_sam_l; ../../../../../../utils/header_files; ../../../../interrupt/system_interrupt_saml21; ../../../../../../../common2/services/delay/sam0; ..; ../../../../../../utils/cmsis/saml21/include; ../../../../clock/clock_saml21; ../../../../../../../common/boards; ../../../../reset/reset_sam_l; ../../../../pinmux; ../../../..; ../../../../../extint; ../../../../../../utils/cmsis/saml21/source; ../../../../clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: power_quick_start_flash.bin
  ILINK.IlinkOutputFile: power_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/saml21_xplained_pro
    ../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/quick_start
    ../../: qs_power.c
  group sam0/drivers/system/power/quick_start/saml21_xplained_pro
    ../: conf_board.h conf_extint.h conf_test.h conf_clocks.h
  group sam0/drivers/system/power/quick_start/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/power/power_sam_l
    ../../../power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../extint/extint_sam_l_c/: extint.c
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../utils/cmsis/saml21/include/component/: ac.h dac.h evsys.h wdt.h dsu.h rtc_100.h dmac.h tcc_200.h nvmctrl_301.h pm_100.h osc32kctrl.h adc_100.h opamp.h trng.h tc_100.h mtb.h aes.h supc_100.h eic_100.h gclk_100.h tal.h pac_100.h ccl.h port.h rstc_100.h mclk_100.h sercom.h oscctrl.h usb.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../utils/cmsis/saml21/include/instance/: tc2_100.h tal.h wdt.h evsys.h pac_100.h eic_100.h rtc_100.h mtb.h sercom0.h sercom2.h dmac.h osc32kctrl.h adc_100.h tc1_100.h oscctrl.h sercom5.h mclk_100.h port.h pm_100.h tc0_100.h tcc0_200.h sercom4.h nvmctrl_301.h usb.h tc3_100.h aes.h ccl.h tc4_100.h supc_100.h dac.h tcc2_200.h dsu.h ac.h opamp.h trng.h gclk_100.h tcc1_200.h sercom1.h rstc_100.h sercom3.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../utils/cmsis/saml21/include/pio/: saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
