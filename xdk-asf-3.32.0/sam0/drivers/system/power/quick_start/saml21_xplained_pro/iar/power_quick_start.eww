<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\power_quick_start_flash.ewp</path>
	</project>
</workspace>
