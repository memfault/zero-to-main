<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\interrupt_quick_start_flash.ewp</path>
	</project>
</workspace>
