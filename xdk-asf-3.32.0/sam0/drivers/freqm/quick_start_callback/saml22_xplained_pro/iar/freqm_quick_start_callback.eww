<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freqm_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
