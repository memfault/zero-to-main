<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freqm_quick_start_flash.ewp</path>
	</project>
</workspace>
