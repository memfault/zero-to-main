<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freqm_unit_test_flash.ewp</path>
	</project>
</workspace>
