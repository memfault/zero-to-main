<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tsens_quick_start_flash.ewp</path>
	</project>
</workspace>
