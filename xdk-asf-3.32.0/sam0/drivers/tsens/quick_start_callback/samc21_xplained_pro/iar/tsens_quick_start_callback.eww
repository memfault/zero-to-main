<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tsens_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
