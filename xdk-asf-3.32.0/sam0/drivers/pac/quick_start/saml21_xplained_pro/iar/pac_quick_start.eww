<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pac_quick_start_flash.ewp</path>
	</project>
</workspace>
