<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_quick_start_slave_callback_flash.ewp</path>
	</project>
</workspace>
