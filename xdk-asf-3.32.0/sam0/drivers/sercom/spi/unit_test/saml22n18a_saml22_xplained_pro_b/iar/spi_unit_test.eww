<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_unit_test_flash.ewp</path>
	</project>
</workspace>
