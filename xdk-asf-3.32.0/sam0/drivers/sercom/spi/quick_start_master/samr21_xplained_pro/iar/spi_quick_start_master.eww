<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_quick_start_master_flash.ewp</path>
	</project>
</workspace>
