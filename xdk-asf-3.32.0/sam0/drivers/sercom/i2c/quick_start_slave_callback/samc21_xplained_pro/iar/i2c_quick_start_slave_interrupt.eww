<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\i2c_quick_start_slave_interrupt_flash.ewp</path>
	</project>
</workspace>
