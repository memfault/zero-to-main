<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\i2c_quick_start_i2c_slave_dma_flash.ewp</path>
	</project>
</workspace>
