# IAR project i2c_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; I2C_SLAVE_CALLBACK_MODE=true; _ASSERT_ENABLE_; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAML21J18B__; I2C_MASTER_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../system/power; ../../../../../system/reset; ../../../i2c_sam0; ../../../../../../utils/preprocessor; ../..; ../../../../../../boards/saml21_xplained_pro_b; ../../../../../../../common2/services/delay; ../../../../../../utils; ../../../..; ../../../../../port; ../../../../../../boards; ../../../../usart; ../../../../../../../common/services/serial; ../../../../../../utils/cmsis/saml21/include_b; ../../..; ../../../../../../../common/utils; ../../../../../system/interrupt; ../../../../../system/power/power_sam_l; ../../../../../../utils/header_files; ../../../../../system/interrupt/system_interrupt_saml21; ../../../../../../../common2/services/delay/sam0; ..; ../../../../../system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../system/reset/reset_sam_l; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/cmsis/saml21/source; ../../../../../../utils/stdio/stdio_serial; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_unit_test_flash.bin
  ILINK.IlinkOutputFile: i2c_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_interrupt.h sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../: i2c_master_interrupt.h i2c_common.h i2c_master.h i2c_slave_interrupt.h i2c_slave.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../i2c_sam0/: i2c_slave_interrupt.c i2c_slave.c i2c_master_interrupt.c i2c_master.c
  group sam0/drivers/sercom/i2c/unit_test
    ../../: unit_test.c
  group sam0/drivers/sercom/i2c/unit_test/saml21j18b_saml21_xplained_pro
    ../: conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/sercom/i2c/unit_test/saml21j18b_saml21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/i2c/quick_start_slave_dma
    ../../../quick_start_slave_dma/: qs_i2c_slave_dma.h
  group sam0/drivers/sercom/i2c/quick_start_master_callback
    ../../../quick_start_master_callback/: qs_i2c_master_callback.h
  group sam0/drivers/sercom/i2c/quick_start_slave_callback
    ../../../quick_start_slave_callback/: qs_i2c_slave_callback.h
  group sam0/drivers/sercom/i2c/quick_start_slave
    ../../../quick_start_slave/: qs_i2c_slave_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/sercom/usart
    ../../../../usart/: usart_interrupt.c usart.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../system/power/power_sam_l/: power.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../utils/cmsis/saml21/include_b/: saml21e15b.h saml21g16b.h saml21.h saml21j17b.h saml21j16b.h saml21j18b.h saml21e17b.h saml21g17b.h saml21e16b.h saml21g18b.h saml21e18b.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../utils/cmsis/saml21/include_b/pio/: saml21e15b.h saml21g18b.h saml21g17b.h saml21e17b.h saml21j18b.h saml21e16b.h saml21g16b.h saml21j17b.h saml21e18b.h saml21j16b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../utils/cmsis/saml21/include_b/instance/: trng.h tcc2.h tcc0.h dsu.h tc2.h ccl.h tal.h mtb.h ac.h evsys.h rtc.h tc4.h sercom0.h sercom2.h eic.h oscctrl.h tc3.h port.h opamp.h tc1.h sercom4.h sercom3.h wdt.h nvmctrl.h mclk.h aes.h pac.h rstc.h sercom1.h dmac.h supc.h tc0.h dac.h sercom5.h adc.h osc32kctrl.h gclk.h pm.h tcc1.h usb.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../utils/cmsis/saml21/include_b/component/: trng.h oscctrl.h supc.h tc.h sercom.h rstc.h dmac.h rtc.h aes.h evsys.h gclk.h mclk.h dsu.h tcc.h dac.h mtb.h eic.h pm.h opamp.h port.h usb.h osc32kctrl.h adc.h wdt.h pac.h ccl.h tal.h nvmctrl.h ac.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
