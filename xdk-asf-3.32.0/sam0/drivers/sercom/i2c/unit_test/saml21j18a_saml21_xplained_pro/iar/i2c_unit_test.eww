<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\i2c_unit_test_flash.ewp</path>
	</project>
</workspace>
