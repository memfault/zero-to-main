<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_unit_test_flash.ewp</path>
	</project>
</workspace>
