<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
