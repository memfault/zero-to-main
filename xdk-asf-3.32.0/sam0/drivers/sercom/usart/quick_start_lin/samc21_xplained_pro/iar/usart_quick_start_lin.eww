<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usart_quick_start_lin_flash.ewp</path>
	</project>
</workspace>
