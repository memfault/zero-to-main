<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_master_vec_quick_start_flash.ewp</path>
	</project>
</workspace>
