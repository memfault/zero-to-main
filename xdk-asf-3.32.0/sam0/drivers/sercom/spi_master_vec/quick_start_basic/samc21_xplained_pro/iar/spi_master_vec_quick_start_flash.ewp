# IAR project spi_master_vec_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMC21_XPLAINED_PRO; __SAMC21J18A__; SPI_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samc21/include; ../../../../../port; ../../../../../system/reset; ../../../../../../utils/cmsis/samc21/source; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../spi; ../../../..; ../../../../../system/power; ../../../../../../boards; ../../../../../system/interrupt/system_interrupt_samc20_c21; ../../../../../system; ../../../../../../../common/utils; ../../../../../system/interrupt; ../../../../../system/power/power_sam_c; ../..; ../../..; ../../../../../system/clock/clock_samc20_c21; ../../../../../system/reset/reset_sam_c; ../../../../../../../common/boards; ../../../../../system/pinmux; ../config; ../../../../../../utils/header_files; ../../../../../../boards/samc21_xplained_pro; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_master_vec_quick_start_flash.bin
  ILINK.IlinkOutputFile: spi_master_vec_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/spi
    ../../../../spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi_master_vec
    ../../../: spi_master_vec.c spi_master_vec.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic
    ../../: qs_spi_master_vec_basic.c qs_spi_master_vec_basic.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic/samc21_xplained_pro/config
    ../config/: conf_spi_master_vec.h conf_spi.h conf_clocks.h conf_board.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic/samc21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../../system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../../system/clock/clock_samc20_c21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../../system/power/power_sam_c/: power.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../../system/reset/reset_sam_c/: reset.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../../utils/cmsis/samc21/include/: samc21.h samc21j17a.h samc21e15a.h samc21j18a.h samc21e18a.h samc21g16a.h samc21g17a.h samc21j16a.h samc21g15a.h samc21j15a.h samc21e17a.h samc21e16a.h samc21g18a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../../utils/cmsis/samc21/include/instance/: tcc2.h port.h ccl.h tcc1.h oscctrl.h tcc0.h tc1.h adc0.h mtb.h rstc.h dac.h divas.h sdadc.h adc1.h can1.h evsys.h tsens.h freqm.h eic.h osc32kctrl.h tal.h rtc.h sercom0.h sercom2.h can0.h dsu.h dmac.h tc4.h sercom1.h tc2.h sercom3.h pm.h hmatrixhs.h ac.h pac.h tc0.h sercom5.h supc.h sercom4.h wdt.h tc3.h mclk.h gclk.h nvmctrl.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../../utils/cmsis/samc21/include/component/: rtc.h adc.h nvmctrl.h evsys.h port.h pac.h sdadc.h mclk.h can.h mtb.h tcc.h oscctrl.h dmac.h pm.h dsu.h ac.h dac.h tc.h osc32kctrl.h gclk.h eic.h tsens.h supc.h tal.h rstc.h ccl.h sercom.h hmatrixb.h freqm.h divas.h wdt.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../../utils/cmsis/samc21/include/pio/: samc21j18a.h samc21e17a.h samc21e16a.h samc21j17a.h samc21j15a.h samc21g15a.h samc21g18a.h samc21j16a.h samc21g17a.h samc21g16a.h samc21e15a.h samc21e18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samc21_xplained_pro
    ../../../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
