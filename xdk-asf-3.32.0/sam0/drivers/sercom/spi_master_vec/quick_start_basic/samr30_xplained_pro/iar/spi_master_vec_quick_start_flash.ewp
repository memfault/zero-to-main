# IAR project spi_master_vec_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../system/power; ../../../../../../utils/cmsis/samr30/source; ../..; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../spi; ../../../..; ../../../../../port; ../../../../../../boards; ../../../../../system/reset; ../../../../../../../common/utils; ../../../../../../boards/samr30_xplained_pro; ../../../../../system/interrupt; ../../../../../system/power/power_sam_l; ../../../../../system/interrupt/system_interrupt_samr30; ../../../../../../utils/cmsis/samr30/include; ../config; ../../..; ../../../../../../../common/boards; ../../../../../system/reset/reset_sam_l; ../../../../../system/pinmux; ../../../../../system; ../../../../../system/clock/clock_samr30; ../../../../../../utils/header_files; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_master_vec_quick_start_flash.bin
  ILINK.IlinkOutputFile: spi_master_vec_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/spi
    ../../../../spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi_master_vec
    ../../../: spi_master_vec.c spi_master_vec.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic
    ../../: qs_spi_master_vec_basic.c qs_spi_master_vec_basic.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic/samr30_xplained_pro/config
    ../config/: conf_spi_master_vec.h conf_spi.h conf_clocks.h conf_board.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic/samr30_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../system/clock/clock_samr30/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../utils/cmsis/samr30/include/: samr30e18a.h samr30g18a.h samr30.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../utils/cmsis/samr30/include/instance/: tc0.h usb.h evsys.h sercom0.h tcc1.h nvmctrl.h rstc.h tc4.h sercom3.h rfctrl.h ccl.h rtc.h eic.h ac.h port.h sercom5.h wdt.h sercom2.h tal.h pac.h osc32kctrl.h mtb.h sercom4.h mclk.h gclk.h tcc0.h adc.h tcc2.h tc1.h sercom1.h dmac.h oscctrl.h pm.h dsu.h supc.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../utils/cmsis/samr30/include/component/: nvmctrl.h mclk.h dmac.h usb.h rstc.h evsys.h dsu.h ac.h supc.h port.h ccl.h pac.h mtb.h gclk.h eic.h adc.h rfctrl.h tal.h tc.h wdt.h sercom.h osc32kctrl.h pm.h rtc.h oscctrl.h tcc.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
