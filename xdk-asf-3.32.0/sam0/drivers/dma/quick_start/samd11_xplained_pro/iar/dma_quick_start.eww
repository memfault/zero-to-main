<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dma_quick_start_flash.ewp</path>
	</project>
</workspace>
