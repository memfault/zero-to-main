<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bod_unit_test_flash.ewp</path>
	</project>
</workspace>
