# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMC21_XPLAINED_PRO; __SAMC21J18A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/cmsis/samc21/include; ../../../../port; ../../../../../boards; ../../../../../utils/cmsis/samc21/source; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../../utils/preprocessor; ../../../bod_sam_c; ..; ../../../../../utils/header_files; ../../../../../../common/utils; ../../../../../boards/samc21_xplained_pro; ../../../../../utils; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/samc21_xplained_pro
    ../../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/bod_sam_c
    ../../../bod_sam_c/: bod.c bod_feature.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use_samc.c
  group sam0/drivers/bod/quick_start/samc21_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/samc21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../utils/cmsis/samc21/include/: samc21g15a.h samc21g17a.h samc21.h samc21e15a.h samc21j18a.h samc21g18a.h samc21e16a.h samc21e18a.h samc21g16a.h samc21j17a.h samc21e17a.h samc21j15a.h samc21j16a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../utils/cmsis/samc21/include/instance/: pm.h wdt.h dmac.h tcc0.h adc1.h rstc.h sercom2.h supc.h can1.h sercom0.h tsens.h evsys.h eic.h gclk.h dsu.h tc0.h tal.h oscctrl.h tc4.h tc3.h tcc1.h port.h freqm.h dac.h divas.h osc32kctrl.h pac.h tc2.h mclk.h mtb.h ac.h sercom5.h ccl.h sercom3.h can0.h sercom1.h adc0.h tcc2.h sercom4.h nvmctrl.h tc1.h sdadc.h rtc.h hmatrixhs.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../utils/cmsis/samc21/include/component/: gclk.h tc.h evsys.h ccl.h pac.h divas.h rstc.h tal.h nvmctrl.h adc.h tsens.h sdadc.h tcc.h mtb.h port.h osc32kctrl.h sercom.h freqm.h dsu.h dac.h ac.h supc.h mclk.h eic.h wdt.h can.h oscctrl.h dmac.h rtc.h hmatrixb.h pm.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../utils/cmsis/samc21/include/pio/: samc21j18a.h samc21j15a.h samc21j17a.h samc21e15a.h samc21e16a.h samc21g16a.h samc21g17a.h samc21g15a.h samc21e18a.h samc21j16a.h samc21e17a.h samc21g18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
