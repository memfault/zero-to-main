<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bod_quick_start_flash.ewp</path>
	</project>
</workspace>
