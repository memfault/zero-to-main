# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../..; ../../../../port; ../../../../../boards; ../../../../../utils/cmsis/saml21/include; ../../../bod_sam_l; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../../utils/cmsis/saml21/source; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../../boards/saml21_xplained_pro; ../../../../../utils/header_files; ..; ../../../../../utils; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../utils/cmsis/saml21/include/: saml21g18a.h saml21e18a.h saml21j18a.h saml21.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../utils/cmsis/saml21/include/pio/: saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../utils/cmsis/saml21/include/component/: oscctrl.h adc_100.h sercom.h wdt.h ccl.h rstc_100.h rtc_100.h opamp.h ac.h usb.h pm_100.h dmac.h gclk_100.h port.h eic_100.h aes.h pac_100.h evsys.h tcc_200.h tal.h dsu.h osc32kctrl.h tc_100.h supc_100.h mclk_100.h nvmctrl_301.h trng.h dac.h mtb.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../utils/cmsis/saml21/include/instance/: trng.h ccl.h rtc_100.h mclk_100.h sercom2.h tc1_100.h wdt.h sercom0.h mtb.h opamp.h tc3_100.h sercom4.h dac.h port.h gclk_100.h sercom1.h pac_100.h ac.h oscctrl.h evsys.h tc0_100.h sercom5.h sercom3.h tc4_100.h tal.h eic_100.h adc_100.h nvmctrl_301.h pm_100.h aes.h dsu.h tcc1_200.h tcc0_200.h tcc2_200.h osc32kctrl.h usb.h supc_100.h rstc_100.h dmac.h tc2_100.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrepeat.h stringz.h mrecursion.h preprocessor.h tpaste.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use_saml.c
  group sam0/drivers/bod/quick_start/saml21_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/bod/bod_sam_l
    ../../../bod_sam_l/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
