# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils; ../../../../port; ../../../../../boards; ../..; ../../../../../../common/boards; ../../../../system/pinmux; ../../../bod_sam_d_r; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/samd11/include; ../../../../../utils/header_files; ../../../../../../common/utils; ..; ../../../../../utils/cmsis/samd11/source; ../../../../../boards/samd11_xplained_pro; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use.c
  group sam0/drivers/bod/quick_start/samd11_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/bod/bod_sam_d_r
    ../../../bod_sam_d_r/: bod.c bod_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../utils/cmsis/samd11/include/: samd11d14as.h samd11c14a.h samd11d14am.h samd11.h samd11d14au.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../utils/cmsis/samd11/include/component/: dmac.h eic.h hmatrixb.h gclk.h dsu.h nvmctrl.h ac.h port.h adc.h tcc.h mtb.h tc.h sysctrl.h pm.h evsys.h sercom.h pac.h usb.h dac.h rtc.h wdt.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../utils/cmsis/samd11/include/instance/: sercom2.h dac.h eic.h mtb.h gclk.h sercom1.h sercom0.h nvmctrl.h sysctrl.h tc1.h dmac.h usb.h wdt.h pac2.h dsu.h sbmatrix.h evsys.h tcc0.h pac0.h tc2.h rtc.h adc.h pm.h port.h ac.h pac1.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../utils/cmsis/samd11/include/pio/: samd11c14a.h samd11d14au.h samd11d14as.h samd11d14am.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h mrecursion.h mrepeat.h tpaste.h stringz.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
