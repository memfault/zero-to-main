<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\events_quick_start_flash.ewp</path>
	</project>
</workspace>
