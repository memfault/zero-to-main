<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\events_unit_test_flash.ewp</path>
	</project>
</workspace>
