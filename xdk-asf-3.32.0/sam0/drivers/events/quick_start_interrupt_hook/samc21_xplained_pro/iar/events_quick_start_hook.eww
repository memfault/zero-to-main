<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\events_quick_start_hook_flash.ewp</path>
	</project>
</workspace>
