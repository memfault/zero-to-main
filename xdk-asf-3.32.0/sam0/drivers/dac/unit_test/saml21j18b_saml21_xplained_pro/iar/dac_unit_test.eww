<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dac_unit_test_flash.ewp</path>
	</project>
</workspace>
