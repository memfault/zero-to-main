# IAR project dac_quick_start_callback_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: RTC_COUNT_ASYNC=true; EVENTS_INTERRUPT_HOOKS_MODE=true; DAC_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; __SAML21J18B__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../..; ../../../../port; ../../../../system/reset; ../../../../system/reset/reset_sam_l; ../../../dac_sam_l; ..; ../../../../../boards/saml21_xplained_pro_b; ../../../../rtc/rtc_sam_l_c; ../../../../../utils; ../../../../system/power; ../../../../../boards; ../..; ../../../../../utils/cmsis/saml21/include_b; ../../../../events/events_sam_l_c; ../../../../rtc; ../../../../../../common/utils; ../../../../system/interrupt; ../../../../system/power/power_sam_l; ../../../../../utils/header_files; ../../../../system/interrupt/system_interrupt_saml21; ../../../../system/clock/clock_saml21; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../system/pinmux; ../../../../system; ../../../../events; ../../../../../utils/cmsis/saml21/source; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_quick_start_callback_flash.bin
  ILINK.IlinkOutputFile: dac_quick_start_callback_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/rtc
    ../../../../rtc/: rtc_tamper.h rtc_count.h rtc_count_interrupt.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../rtc/rtc_sam_l_c/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/dac
    ../../../: dac.h dac_callback.h
  group sam0/drivers/dac/quick_start_callback
    ../../: qs_dac_callback.c
  group sam0/drivers/dac/quick_start_callback/saml21_xplained_pro_b
    ../: conf_rtc.h conf_board.h conf_clocks.h
  group sam0/drivers/dac/quick_start_callback/saml21_xplained_pro_b/iar
    ./: asf.h
  group sam0/drivers/dac/dac_sam_l
    ../../../dac_sam_l/: dac.c dac_callback.c dac_feature.h
  group sam0/drivers/events
    ../../../../events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../events/events_sam_l_c/: events.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../utils/cmsis/saml21/include_b/: saml21j16b.h saml21.h saml21e18b.h saml21e17b.h saml21g18b.h saml21j17b.h saml21e15b.h saml21j18b.h saml21e16b.h saml21g16b.h saml21g17b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../utils/cmsis/saml21/include_b/instance/: tc3.h pm.h supc.h tc1.h dac.h tal.h mtb.h oscctrl.h gclk.h rstc.h port.h tc2.h tcc1.h tc0.h tcc2.h sercom3.h trng.h tc4.h sercom1.h mclk.h pac.h usb.h evsys.h ccl.h tcc0.h ac.h adc.h sercom2.h nvmctrl.h osc32kctrl.h sercom0.h eic.h wdt.h sercom5.h dmac.h rtc.h dsu.h opamp.h aes.h sercom4.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../utils/cmsis/saml21/include_b/component/: oscctrl.h aes.h pm.h supc.h pac.h trng.h rstc.h osc32kctrl.h tcc.h mtb.h ccl.h evsys.h dmac.h usb.h ac.h adc.h port.h dac.h gclk.h dsu.h opamp.h tal.h eic.h tc.h sercom.h wdt.h nvmctrl.h rtc.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../utils/cmsis/saml21/include_b/pio/: saml21j16b.h saml21g17b.h saml21j18b.h saml21e17b.h saml21g16b.h saml21j17b.h saml21e16b.h saml21g18b.h saml21e18b.h saml21e15b.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
