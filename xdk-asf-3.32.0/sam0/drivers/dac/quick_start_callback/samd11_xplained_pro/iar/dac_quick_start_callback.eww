<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dac_quick_start_callback_flash.ewp</path>
	</project>
</workspace>
