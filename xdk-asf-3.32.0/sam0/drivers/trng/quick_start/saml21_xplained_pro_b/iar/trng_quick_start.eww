<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\trng_quick_start_flash.ewp</path>
	</project>
</workspace>
