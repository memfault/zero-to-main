<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_quick_start_count_polled_flash.ewp</path>
	</project>
</workspace>
