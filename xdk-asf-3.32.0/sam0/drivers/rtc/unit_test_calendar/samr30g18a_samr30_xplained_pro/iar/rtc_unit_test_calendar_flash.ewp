# IAR project rtc_unit_test_calendar_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAMR30G18A__; SYSTICK_MODE; _ASSERT_ENABLE_; USART_CALLBACK_MODE=true; RTC_CALENDAR_ASYNC=true; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAMR30_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../system/power; ../../../../../utils/cmsis/samr30/source; ../../../rtc_sam_l_c; ../../../../../utils/preprocessor; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../sercom; ../../../../port; ../../../../../boards; ../../../../sercom/usart; ..; ../../../../../../common/services/serial; ../../../../system/reset; ../../..; ../../../../../../common/utils; ../../../../../boards/samr30_xplained_pro; ../../../../system/interrupt; ../../../../system/power/power_sam_l; ../../../../system/interrupt/system_interrupt_samr30; ../..; ../../../../../utils/cmsis/samr30/include; ../../../../../../common2/services/delay/sam0; ../../../../../../common/boards; ../../../../system/reset/reset_sam_l; ../../../../system/pinmux; ../../../../system; ../../../../system/clock/clock_samr30; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtc_unit_test_calendar_flash.bin
  ILINK.IlinkOutputFile: rtc_unit_test_calendar_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../system/clock/clock_samr30/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/rtc
    ../../../: rtc_tamper.h rtc_calendar.h rtc_calendar_interrupt.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../rtc_sam_l_c/: rtc_calendar_interrupt.c rtc_calendar.c
  group sam0/drivers/rtc/unit_test_calendar
    ../../: unit_test.c
  group sam0/drivers/rtc/unit_test_calendar/samr30g18a_samr30_xplained_pro
    ../: conf_rtc.h conf_board.h conf_test.h conf_clocks.h
  group sam0/drivers/rtc/unit_test_calendar/samr30g18a_samr30_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom
    ../../../../sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../utils/cmsis/samr30/include/: samr30g18a.h samr30.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../utils/cmsis/samr30/include/component/: eic.h supc.h ac.h wdt.h tc.h mtb.h dsu.h adc.h tal.h sercom.h pm.h nvmctrl.h osc32kctrl.h ccl.h dmac.h rfctrl.h pac.h rtc.h port.h rstc.h usb.h tcc.h evsys.h oscctrl.h mclk.h gclk.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../utils/cmsis/samr30/include/instance/: mclk.h supc.h tcc0.h tc1.h ac.h pm.h oscctrl.h gclk.h port.h rstc.h wdt.h ccl.h sercom1.h dmac.h tal.h tcc2.h nvmctrl.h adc.h rfctrl.h rtc.h evsys.h pac.h tc4.h usb.h sercom4.h osc32kctrl.h tcc1.h tc0.h sercom3.h sercom0.h mtb.h eic.h sercom5.h dsu.h sercom2.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
