<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_unit_test_calendar_flash.ewp</path>
	</project>
</workspace>
