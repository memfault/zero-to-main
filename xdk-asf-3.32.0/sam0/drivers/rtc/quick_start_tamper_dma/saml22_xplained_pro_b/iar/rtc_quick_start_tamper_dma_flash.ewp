# IAR project rtc_quick_start_tamper_dma_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAML22_XPLAINED_PRO_B; __SAML22N18A__; RTC_COUNT_ASYNC=true
  ICCARM.CCIncludePath2: ../../../../system/power; ../../../../system/reset; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/saml22/include; ../../../../dma; ../../../rtc_sam_l_c; ../../../../../utils; ../../../../port; ../../../../../boards; ../../..; ../../../../../utils/cmsis/saml22/source; ../../../../system/interrupt; ../../../../system/power/power_sam_l; ../../../../../boards/saml22_xplained_pro_b; ../../../../system/interrupt/system_interrupt_saml22; ../../../../../../common/utils; ..; ../..; ../../../../system/clock/clock_saml22; ../../../../../../common/boards; ../../../../system/reset/reset_sam_l; ../../../../system/pinmux; ../../../../system; ../../../../../utils/header_files; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtc_quick_start_tamper_dma_flash.bin
  ILINK.IlinkOutputFile: rtc_quick_start_tamper_dma_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../system/clock/clock_saml22/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/rtc
    ../../../: rtc_tamper.h rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../rtc_sam_l_c/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/rtc/quick_start_tamper_dma
    ../../: qs_rtc_tamper_dma.c
  group sam0/drivers/rtc/quick_start_tamper_dma/saml22_xplained_pro_b
    ../: conf_rtc.h conf_board.h conf_clocks.h conf_dma.h
  group sam0/drivers/rtc/quick_start_tamper_dma/saml22_xplained_pro_b/iar
    ./: asf.h
  group sam0/drivers/dma
    ../../../../dma/: dma.c dma_crc.h dma.h
  group sam0/drivers/dma/quick_start
    ../../../../dma/quick_start/: qs_dma_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../utils/cmsis/saml22/include/: saml22g16a.h saml22n17a.h saml22j18a.h saml22g18a.h saml22.h saml22j16a.h saml22n18a.h saml22n16a.h saml22g17a.h saml22j17a.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../utils/cmsis/saml22/include/component/: adc.h supc.h rtc.h port.h tc.h mclk.h sercom.h aes.h evsys.h eic.h pac.h rstc.h usb.h ac.h pm.h wdt.h tal.h trng.h freqm.h oscctrl.h gclk.h osc32kctrl.h ccl.h mtb.h dsu.h tcc.h dmac.h nvmctrl.h slcd.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../utils/cmsis/saml22/include/instance/: pm.h supc.h evsys.h tc3.h dsu.h tc0.h sercom3.h sercom1.h rtc.h mclk.h sercom5.h slcd.h eic.h tc1.h ccl.h sercom0.h nvmctrl.h usb.h rstc.h tc2.h osc32kctrl.h tcc0.h sercom4.h aes.h sercom2.h gclk.h dmac.h freqm.h trng.h pac.h wdt.h ac.h tal.h adc.h oscctrl.h mtb.h port.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../utils/cmsis/saml22/include/pio/: saml22j17a.h saml22g16a.h saml22n16a.h saml22j18a.h saml22n17a.h saml22g18a.h saml22g17a.h saml22n18a.h saml22j16a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrepeat.h stringz.h mrecursion.h preprocessor.h tpaste.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
