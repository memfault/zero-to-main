<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_quick_start_tamper_dma_flash.ewp</path>
	</project>
</workspace>
