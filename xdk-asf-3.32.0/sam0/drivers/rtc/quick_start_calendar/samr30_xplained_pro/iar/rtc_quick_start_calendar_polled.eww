<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rtc_quick_start_calendar_polled_flash.ewp</path>
	</project>
</workspace>
