# IAR project rtc_quick_start_calendar_interrupt_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; ARM_MATH_CM0PLUS=true; RTC_CALENDAR_ASYNC=true; BOARD=SAMR30_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../system/power; ../../../../../utils/cmsis/samr30/source; ../../../../../utils/preprocessor; ../../../rtc_sam_l_c; ../../../../../utils; ../../../../port; ../../../../../boards; ../../../../system/reset; ../../..; ../../../../../../common/utils; ../../../../../boards/samr30_xplained_pro; ..; ../../../../system/interrupt; ../../../../system/power/power_sam_l; ../../../../system/interrupt/system_interrupt_samr30; ../../../../../utils/cmsis/samr30/include; ../../../../../../common/boards; ../../../../system/reset/reset_sam_l; ../../../../system/pinmux; ../../../../system; ../..; ../../../../system/clock/clock_samr30; ../../../../../utils/header_files; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtc_quick_start_calendar_interrupt_flash.bin
  ILINK.IlinkOutputFile: rtc_quick_start_calendar_interrupt_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../system/clock/clock_samr30/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../system/reset/reset_sam_l/: reset.h
  group sam0/drivers/rtc
    ../../../: rtc_tamper.h rtc_calendar.h rtc_calendar_interrupt.h
  group sam0/drivers/rtc/quick_start_calendar_callback
    ../../: qs_rtc_calendar_callback.c
  group sam0/drivers/rtc/quick_start_calendar_callback/samr30_xplained_pro
    ../: conf_rtc.h conf_board.h conf_clocks.h
  group sam0/drivers/rtc/quick_start_calendar_callback/samr30_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../rtc_sam_l_c/: rtc_calendar_interrupt.c rtc_calendar.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../utils/cmsis/samr30/include/: samr30g18a.h samr30.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../utils/cmsis/samr30/include/component/: eic.h supc.h ac.h wdt.h tc.h mtb.h dsu.h adc.h tal.h sercom.h pm.h nvmctrl.h osc32kctrl.h ccl.h dmac.h rfctrl.h pac.h rtc.h port.h rstc.h usb.h tcc.h evsys.h oscctrl.h mclk.h gclk.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../utils/cmsis/samr30/include/instance/: mclk.h supc.h tcc0.h tc1.h ac.h pm.h oscctrl.h gclk.h port.h rstc.h wdt.h ccl.h sercom1.h dmac.h tal.h tcc2.h nvmctrl.h adc.h rfctrl.h rtc.h evsys.h pac.h tc4.h usb.h sercom4.h osc32kctrl.h tcc1.h tc0.h sercom3.h sercom0.h mtb.h eic.h sercom5.h dsu.h sercom2.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
