# IAR project rtc_quick_start_calendar_interrupt_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMC21_XPLAINED_PRO; __SAMC21J18A__; RTC_CALENDAR_ASYNC=true; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samc21/include; ../../../../port; ../../../../system/reset; ../../../../../utils/cmsis/samc21/source; ../../../../../utils/preprocessor; ../../../rtc_sam_l_c; ../../../../../utils; ../../../../system/power; ../../../../../boards; ../../../../system/interrupt/system_interrupt_samc20_c21; ../../..; ../../../../../../common/utils; ../../../../system/interrupt; ../../../../system/power/power_sam_c; ../../../../system/clock/clock_samc20_c21; ../../../../system/reset/reset_sam_c; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../system; ../..; ../../../../../utils/header_files; ../../../../../boards/samc21_xplained_pro; ..; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtc_quick_start_calendar_interrupt_flash.bin
  ILINK.IlinkOutputFile: rtc_quick_start_calendar_interrupt_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../system/clock/clock_samc20_c21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../system/reset/reset_sam_c/: reset.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../system/power/power_sam_c/: power.h
  group sam0/drivers/rtc
    ../../../: rtc_tamper.h rtc_calendar.h rtc_calendar_interrupt.h
  group sam0/drivers/rtc/quick_start_calendar_callback
    ../../: qs_rtc_calendar_callback.c
  group sam0/drivers/rtc/quick_start_calendar_callback/samc21_xplained_pro
    ../: conf_rtc.h conf_board.h conf_clocks.h
  group sam0/drivers/rtc/quick_start_calendar_callback/samc21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../rtc_sam_l_c/: rtc_calendar_interrupt.c rtc_calendar.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samc21_xplained_pro
    ../../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../utils/cmsis/samc21/include/: samc21g15a.h samc21g17a.h samc21.h samc21e15a.h samc21j18a.h samc21g18a.h samc21e16a.h samc21e18a.h samc21g16a.h samc21j17a.h samc21e17a.h samc21j15a.h samc21j16a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../utils/cmsis/samc21/include/instance/: pm.h wdt.h dmac.h tcc0.h adc1.h rstc.h sercom2.h supc.h can1.h sercom0.h tsens.h evsys.h eic.h gclk.h dsu.h tc0.h tal.h oscctrl.h tc4.h tc3.h tcc1.h port.h freqm.h dac.h divas.h osc32kctrl.h pac.h tc2.h mclk.h mtb.h sercom5.h ac.h ccl.h sercom3.h can0.h sercom1.h adc0.h tcc2.h sercom4.h nvmctrl.h tc1.h sdadc.h rtc.h hmatrixhs.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../utils/cmsis/samc21/include/component/: gclk.h tc.h evsys.h ccl.h pac.h divas.h rstc.h tal.h nvmctrl.h adc.h tsens.h sdadc.h mtb.h port.h osc32kctrl.h sercom.h freqm.h oscctrl.h dsu.h dac.h ac.h supc.h mclk.h eic.h wdt.h can.h tcc.h dmac.h rtc.h hmatrixb.h pm.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../utils/cmsis/samc21/include/pio/: samc21j18a.h samc21j15a.h samc21j17a.h samc21e15a.h samc21e16a.h samc21g16a.h samc21g17a.h samc21g15a.h samc21e18a.h samc21j16a.h samc21e17a.h samc21g18a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: mrecursion.h stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
