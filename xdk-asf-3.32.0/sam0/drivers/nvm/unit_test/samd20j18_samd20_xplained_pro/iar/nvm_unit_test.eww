<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_unit_test_flash.ewp</path>
	</project>
</workspace>
