<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\nvm_quick_start_flash.ewp</path>
	</project>
</workspace>
