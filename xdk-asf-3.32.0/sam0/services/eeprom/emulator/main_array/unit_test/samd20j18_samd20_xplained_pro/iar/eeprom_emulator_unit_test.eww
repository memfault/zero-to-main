<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\eeprom_emulator_unit_test_flash.ewp</path>
	</project>
</workspace>
