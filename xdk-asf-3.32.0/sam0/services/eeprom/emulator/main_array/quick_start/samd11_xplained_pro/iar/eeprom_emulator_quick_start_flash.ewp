# IAR project eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/bod/bod_sam_d_r; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/system/clock/clock_samd09_d10_d11; ../../../../../../../utils; ../../../../../../../boards/samd11_xplained_pro; ../../..; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../..; ../../../../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../../../../../common/utils; ..; ../../../../../../../utils/cmsis/samd11/source; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/bod; ../../../../../../../drivers/system/power/power_sam_d_r; ../../../../../../../drivers/system/reset/reset_sam_d_r; ../../../../../../../utils/cmsis/samd11/include; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd09_d10_d11
    ../../../../../../../drivers/system/clock/clock_samd09_d10_d11/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_d_r
    ../../../../../../../drivers/bod/bod_sam_d_r/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/services/eeprom/emulator/main_array
    ../../../: eeprom.c eeprom.h
  group sam0/services/eeprom/emulator/main_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/main_array/quick_start/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/services/eeprom/emulator/main_array/quick_start/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../../utils/cmsis/samd11/include/: samd11c14a.h samd11d14am.h samd11d14as.h samd11d14au.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../../utils/cmsis/samd11/include/component/: port.h dac.h gclk.h sysctrl.h mtb.h dsu.h dmac.h nvmctrl.h eic.h adc.h usb.h pac.h pm.h ac.h wdt.h tc.h sercom.h hmatrixb.h tcc.h evsys.h rtc.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11c14a.h samd11d14au.h samd11d14as.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../../utils/cmsis/samd11/include/instance/: pac1.h dsu.h mtb.h sercom0.h ac.h rtc.h tcc0.h eic.h sercom2.h port.h pm.h nvmctrl.h usb.h sbmatrix.h dac.h tc1.h dmac.h gclk.h sysctrl.h wdt.h tc2.h pac2.h adc.h pac0.h evsys.h sercom1.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
