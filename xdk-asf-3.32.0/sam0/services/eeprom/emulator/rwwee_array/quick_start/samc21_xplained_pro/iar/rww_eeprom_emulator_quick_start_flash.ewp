# IAR project rww_eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMC21_XPLAINED_PRO; __SAMC21J18A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../../utils/cmsis/samc21/include; ../../../../../../../drivers/port; ../../../../../../../drivers/system/reset; ../../../../../../../utils/cmsis/samc21/source; ../../../../../../../utils/preprocessor; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/system/power; ../../../../../../../boards; ..; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/bod; ../../../../../../../drivers/system/power/power_sam_c; ../../../../../../../drivers/system/clock/clock_samc20_c21; ../../../../../../../drivers/system/reset/reset_sam_c; ../..; ../../../../../../../../common/boards; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system/interrupt/system_interrupt_samc20_c21; ../../../../../../../drivers/system; ../../../../../../../drivers/bod/bod_sam_c; ../../../../../../../utils/header_files; ../../../../../../../boards/samc21_xplained_pro; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../../../../drivers/system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../../../../drivers/system/clock/clock_samc20_c21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../../../../drivers/system/power/power_sam_c/: power.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../../../../drivers/system/reset/reset_sam_c/: reset.h
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_c
    ../../../../../../../drivers/bod/bod_sam_c/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/samc21_xplained_pro
    ../../../../../../../boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/samc21_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/samc21_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../../../utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../../../utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../../../utils/cmsis/samc21/include/: samc21j17a.h samc21j18a.h samc21j15a.h samc21g15a.h samc21g18a.h samc21.h samc21e18a.h samc21g16a.h samc21e16a.h samc21e17a.h samc21g17a.h samc21j16a.h samc21e15a.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../../../utils/cmsis/samc21/include/instance/: tc2.h tcc1.h wdt.h can1.h tcc2.h mclk.h eic.h tc1.h hmatrixhs.h tsens.h ccl.h dsu.h gclk.h sercom3.h tc4.h dmac.h evsys.h tc0.h pac.h sercom1.h pm.h sercom5.h sercom2.h oscctrl.h freqm.h ac.h supc.h sercom0.h nvmctrl.h rstc.h can0.h adc1.h rtc.h adc0.h sercom4.h tc3.h sdadc.h divas.h mtb.h osc32kctrl.h tcc0.h tal.h port.h dac.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../../../utils/cmsis/samc21/include/component/: can.h pac.h nvmctrl.h oscctrl.h dsu.h mclk.h rtc.h pm.h mtb.h wdt.h freqm.h tsens.h tc.h supc.h dac.h evsys.h ccl.h gclk.h eic.h sercom.h hmatrixb.h adc.h divas.h tcc.h dmac.h tal.h sdadc.h ac.h port.h osc32kctrl.h rstc.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../../../utils/cmsis/samc21/include/pio/: samc21j18a.h samc21e17a.h samc21e18a.h samc21j15a.h samc21g16a.h samc21j17a.h samc21e15a.h samc21j16a.h samc21g15a.h samc21g17a.h samc21g18a.h samc21e16a.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
