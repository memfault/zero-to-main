# IAR project rww_eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/bod; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../utils/preprocessor; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/system/power/power_sam_l; ../../../../../../../utils/header_files; ../../../../../../../boards/saml21_xplained_pro; ..; ../..; ../../../../../../../utils/cmsis/saml21/include; ../../../../../../../drivers/system/clock/clock_saml21; ../../../../../../../../common/boards; ../../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/cmsis/saml21/source; ../../../../../../../drivers/bod/bod_sam_l; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_l
    ../../../../../../../drivers/bod/bod_sam_l/: bod.c bod_feature.h
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/saml21_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../utils/cmsis/saml21/include/instance/: tc2_100.h ccl.h tc1_100.h trng.h tcc1_200.h ac.h pac_100.h pm_100.h rtc_100.h dmac.h mclk_100.h rstc_100.h dsu.h eic_100.h tc4_100.h tc3_100.h evsys.h wdt.h adc_100.h sercom0.h usb.h opamp.h oscctrl.h sercom4.h osc32kctrl.h supc_100.h gclk_100.h sercom2.h nvmctrl_301.h sercom1.h tcc2_200.h tc0_100.h tcc0_200.h sercom3.h sercom5.h port.h mtb.h tal.h aes.h dac.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../utils/cmsis/saml21/include/component/: aes.h evsys.h mtb.h mclk_100.h nvmctrl_301.h supc_100.h rtc_100.h tal.h gclk_100.h port.h pac_100.h dsu.h opamp.h tcc_200.h osc32kctrl.h tc_100.h sercom.h eic_100.h rstc_100.h adc_100.h wdt.h ac.h usb.h dac.h ccl.h dmac.h trng.h pm_100.h oscctrl.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../utils/cmsis/saml21/include/pio/: saml21g18a.h saml21e18a.h saml21j18a.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
