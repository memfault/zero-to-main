<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\rww_eeprom_emulator_quick_start_flash.ewp</path>
	</project>
</workspace>
