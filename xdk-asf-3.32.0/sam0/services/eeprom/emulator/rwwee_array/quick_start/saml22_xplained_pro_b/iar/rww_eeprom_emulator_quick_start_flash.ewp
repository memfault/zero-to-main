# IAR project rww_eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAML22_XPLAINED_PRO_B; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/bod; ../../../../../../../drivers/system/reset; ../../../../../../../utils/preprocessor; ../../../../../../../utils/cmsis/saml22/include; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../utils/cmsis/saml22/source; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/system/power/power_sam_l; ../../../../../../../boards/saml22_xplained_pro_b; ../../../../../../../drivers/system/interrupt/system_interrupt_saml22; ../../../../../../../../common/utils; ../..; ..; ../../../../../../../drivers/system/clock/clock_saml22; ../../../../../../../../common/boards; ../../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/header_files; ../../../../../../../drivers/bod/bod_sam_l; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_l
    ../../../../../../../drivers/bod/bod_sam_l/: bod.c bod_feature.h
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../../drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../../drivers/system/clock/clock_saml22/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/saml22_xplained_pro_b
    ../: conf_board.h conf_rwwee.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/saml22_xplained_pro_b/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../../utils/cmsis/saml22/include/: saml22.h saml22g18a.h saml22j17a.h saml22j18a.h saml22g16a.h saml22g17a.h saml22j16a.h saml22n16a.h saml22n18a.h saml22n17a.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../../utils/cmsis/saml22/include/instance/: slcd.h rtc.h mclk.h sercom1.h osc32kctrl.h tc0.h sercom4.h adc.h dmac.h tc2.h nvmctrl.h wdt.h freqm.h rstc.h sercom0.h sercom5.h tal.h ac.h pm.h trng.h supc.h pac.h usb.h eic.h sercom3.h gclk.h sercom2.h port.h dsu.h oscctrl.h tcc0.h tc1.h ccl.h mtb.h aes.h evsys.h tc3.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../../utils/cmsis/saml22/include/component/: adc.h oscctrl.h freqm.h sercom.h wdt.h ac.h dsu.h tc.h osc32kctrl.h usb.h mclk.h aes.h nvmctrl.h dmac.h rtc.h gclk.h ccl.h pm.h pac.h supc.h tal.h evsys.h mtb.h eic.h trng.h rstc.h port.h slcd.h tcc.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../../utils/cmsis/saml22/include/pio/: saml22n18a.h saml22n16a.h saml22j18a.h saml22g16a.h saml22n17a.h saml22g18a.h saml22j17a.h saml22j16a.h saml22g17a.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../../boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
