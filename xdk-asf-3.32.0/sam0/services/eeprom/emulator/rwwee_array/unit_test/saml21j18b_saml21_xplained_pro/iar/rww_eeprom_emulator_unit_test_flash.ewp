# IAR project rww_eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAML21J18B__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../utils/preprocessor; ../..; ../../../../../../../boards/saml21_xplained_pro_b; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/sercom; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../drivers/sercom/usart; ../../../../../../../../common/services/serial; ../../../../../../../utils/cmsis/saml21/include_b; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/system/power/power_sam_l; ..; ../../../../../../../utils/header_files; ../../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../drivers/system/clock/clock_saml21; ../../../../../../../../common/boards; ../../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/cmsis/saml21/source; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../../utils/cmsis/saml21/include_b/: saml21e17b.h saml21j17b.h saml21e16b.h saml21e18b.h saml21j18b.h saml21g17b.h saml21e15b.h saml21j16b.h saml21.h saml21g16b.h saml21g18b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../../utils/cmsis/saml21/include_b/instance/: sercom0.h oscctrl.h ccl.h pac.h mtb.h sercom2.h tc1.h dac.h eic.h adc.h mclk.h osc32kctrl.h tcc0.h dmac.h tal.h tc3.h tcc2.h tc4.h wdt.h ac.h rstc.h trng.h opamp.h sercom5.h rtc.h aes.h port.h supc.h tcc1.h tc2.h tc0.h gclk.h nvmctrl.h sercom4.h sercom1.h sercom3.h usb.h evsys.h dsu.h pm.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../../utils/cmsis/saml21/include_b/component/: aes.h pm.h tc.h trng.h ac.h adc.h gclk.h tcc.h dmac.h oscctrl.h pac.h rstc.h port.h nvmctrl.h eic.h supc.h opamp.h rtc.h usb.h ccl.h mtb.h tal.h dac.h evsys.h osc32kctrl.h wdt.h mclk.h dsu.h sercom.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../../utils/cmsis/saml21/include_b/pio/: saml21e18b.h saml21g18b.h saml21e16b.h saml21j17b.h saml21e17b.h saml21g17b.h saml21g16b.h saml21e15b.h saml21j16b.h saml21j18b.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/rwwee_array/unit_test/saml21j18b_saml21_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/unit_test/saml21j18b_saml21_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
