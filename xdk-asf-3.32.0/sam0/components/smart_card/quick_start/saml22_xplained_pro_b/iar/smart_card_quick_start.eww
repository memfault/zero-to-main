<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\smart_card_quick_start_flash.ewp</path>
	</project>
</workspace>
