# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; I2C_MASTER_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/power; ../../../../../../utils/cmsis/samr30/source; ../../../../../../drivers/sercom/i2c/i2c_sam0; ../..; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../../../drivers/sercom; ../../../../../../drivers/port; ../../../../../../boards; ../../../../../../drivers/sercom/i2c; ../../../../../../../common/utils; ../../../../../../boards/samr30_xplained_pro; ..; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/power/power_sam_l; ../../../../../../drivers/system/interrupt/system_interrupt_samr30; ../../../../../../utils/cmsis/samr30/include; ../../..; ../../../../../../../common/boards; ../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../drivers/system/clock/clock_samr30; ../../../../../../drivers/system/reset; ../../../../../../utils/header_files; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../drivers/system/clock/clock_samr30/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../../../../drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../drivers/sercom/i2c/i2c_sam0/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start/samr30_xplained_pro
    ../: conf_board.h conf_at30tse75x.h conf_clocks.h
  group sam0/components/sensor/at30tse75x/quick_start/samr30_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../utils/cmsis/samr30/include/: samr30e18a.h samr30.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../utils/cmsis/samr30/include/instance/: tc0.h usb.h evsys.h sercom0.h tcc1.h nvmctrl.h rstc.h tc4.h sercom3.h rfctrl.h ccl.h rtc.h ac.h port.h sercom5.h wdt.h sercom2.h tal.h pac.h osc32kctrl.h mtb.h eic.h sercom4.h mclk.h gclk.h tcc0.h adc.h tcc2.h tc1.h sercom1.h dmac.h oscctrl.h pm.h dsu.h supc.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../utils/cmsis/samr30/include/component/: nvmctrl.h adc.h mclk.h dmac.h usb.h osc32kctrl.h rstc.h evsys.h dsu.h ac.h supc.h port.h ccl.h pac.h mtb.h gclk.h eic.h rfctrl.h tal.h tc.h wdt.h sercom.h pm.h rtc.h oscctrl.h tcc.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
