<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\at30tse75x_quick_start_flash.ewp</path>
	</project>
</workspace>
