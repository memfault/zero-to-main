# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAML21J18A__; I2C_MASTER_CALLBACK_MODE=false; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/power; ../../../../../../drivers/system/reset; ../../../../../../drivers/sercom/i2c/i2c_sam0; ../../../../../../boards/saml21_xplained_pro; ..; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../../../drivers/sercom; ../../../../../../drivers/port; ../../../../../../boards; ../../../../../../drivers/sercom/i2c; ../../../../../../../common/utils; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/power/power_sam_l; ../../../../../../utils/header_files; ../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../..; ../../..; ../../../../../../utils/cmsis/saml21/include; ../../../../../../drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../utils/cmsis/saml21/source; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../../../../drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../drivers/sercom/i2c/i2c_sam0/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start/saml21_xplained_pro
    ../: conf_board.h conf_at30tse75x.h conf_clocks.h
  group sam0/components/sensor/at30tse75x/quick_start/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../utils/cmsis/saml21/include/component/: ac.h dac.h evsys.h wdt.h dsu.h rtc_100.h dmac.h tcc_200.h nvmctrl_301.h pm_100.h osc32kctrl.h adc_100.h mtb.h trng.h tc_100.h opamp.h aes.h supc_100.h eic_100.h gclk_100.h tal.h pac_100.h ccl.h port.h rstc_100.h mclk_100.h sercom.h oscctrl.h usb.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../utils/cmsis/saml21/include/instance/: tc2_100.h tal.h wdt.h evsys.h pac_100.h eic_100.h sercom4.h rtc_100.h mtb.h sercom0.h dmac.h osc32kctrl.h adc_100.h sercom2.h tc1_100.h tc3_100.h sercom5.h mclk_100.h port.h pm_100.h tc0_100.h tcc0_200.h nvmctrl_301.h usb.h oscctrl.h aes.h ccl.h tc4_100.h supc_100.h dac.h tcc2_200.h dsu.h ac.h opamp.h trng.h gclk_100.h tcc1_200.h sercom1.h rstc_100.h sercom3.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../utils/cmsis/saml21/include/pio/: saml21e18a.h saml21j18a.h saml21g18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
