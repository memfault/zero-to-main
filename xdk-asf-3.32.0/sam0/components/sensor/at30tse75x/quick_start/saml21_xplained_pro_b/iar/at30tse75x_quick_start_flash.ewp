# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAML21J18B__; I2C_MASTER_CALLBACK_MODE=false; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/power; ../../../../../../drivers/system/reset; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../boards/saml21_xplained_pro_b; ../../../../../../utils; ../../../../../../drivers/sercom; ../../../../../../drivers/port; ../../../../../../boards; ../../../../../../utils/cmsis/saml21/include_b; ../../../../../../drivers/sercom/i2c; ../../../../../../drivers/sercom/i2c/i2c_sam0; ../../../../../../../common/utils; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/power/power_sam_l; ../../../../../../utils/header_files; ../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../..; ../../..; ../../../../../../drivers/system/clock/clock_saml21; ..; ../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../utils/cmsis/saml21/source; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../../../../drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../drivers/sercom/i2c/i2c_sam0/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start/saml21_xplained_pro_b
    ../: conf_board.h conf_at30tse75x.h conf_clocks.h
  group sam0/components/sensor/at30tse75x/quick_start/saml21_xplained_pro_b/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../utils/cmsis/saml21/include_b/: saml21e15b.h saml21g16b.h saml21.h saml21j17b.h saml21j16b.h saml21j18b.h saml21e17b.h saml21g17b.h saml21e18b.h saml21g18b.h saml21e16b.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../utils/cmsis/saml21/include_b/pio/: saml21e15b.h saml21g18b.h saml21g17b.h saml21e17b.h saml21e16b.h saml21g16b.h saml21j17b.h saml21e18b.h saml21j18b.h saml21j16b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../utils/cmsis/saml21/include_b/instance/: trng.h tcc2.h tcc0.h dsu.h tc2.h ccl.h tal.h mtb.h ac.h evsys.h rtc.h oscctrl.h tc4.h sercom0.h sercom2.h eic.h tc3.h port.h opamp.h tc1.h sercom4.h sercom3.h wdt.h nvmctrl.h mclk.h aes.h pac.h rstc.h sercom1.h dmac.h supc.h tc0.h dac.h sercom5.h adc.h osc32kctrl.h gclk.h pm.h tcc1.h usb.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../utils/cmsis/saml21/include_b/component/: trng.h oscctrl.h supc.h tc.h sercom.h rstc.h dmac.h rtc.h aes.h evsys.h gclk.h mclk.h dsu.h tcc.h dac.h eic.h mtb.h pm.h opamp.h port.h usb.h osc32kctrl.h adc.h wdt.h pac.h ccl.h tal.h nvmctrl.h ac.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
