# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAML22_XPLAINED_PRO_B; __SAML22N18A__; I2C_MASTER_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/power; ../../../../../../drivers/system/reset; ../../../../../../drivers/sercom/i2c/i2c_sam0; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/saml22/include; ../../../../../../utils; ../../../../../../drivers/sercom; ../../../../../../drivers/port; ../../../../../../boards; ../../../../../../drivers/sercom/i2c; ..; ../../../../../../utils/cmsis/saml22/source; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/power/power_sam_l; ../../../../../../boards/saml22_xplained_pro_b; ../../../../../../drivers/system/interrupt/system_interrupt_saml22; ../../../../../../../common/utils; ../..; ../../..; ../../../../../../drivers/system/clock/clock_saml22; ../../../../../../../common/boards; ../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../utils/header_files; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../drivers/system/clock/clock_saml22/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../../../../drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../drivers/sercom/i2c/i2c_sam0/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start/saml22_xplained_pro_b
    ../: conf_board.h conf_at30tse75x.h conf_clocks.h
  group sam0/components/sensor/at30tse75x/quick_start/saml22_xplained_pro_b/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../utils/cmsis/saml22/include/: saml22n16a.h saml22g16a.h saml22.h saml22j16a.h saml22n17a.h saml22g18a.h saml22j18a.h saml22j17a.h saml22n18a.h saml22g17a.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../utils/cmsis/saml22/include/pio/: saml22n16a.h saml22n18a.h saml22g16a.h saml22j18a.h saml22j17a.h saml22j16a.h saml22g18a.h saml22n17a.h saml22g17a.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../utils/cmsis/saml22/include/instance/: rstc.h tal.h tc0.h usb.h pm.h tc2.h nvmctrl.h tcc0.h tc1.h sercom2.h slcd.h osc32kctrl.h sercom4.h ccl.h freqm.h aes.h dsu.h adc.h sercom0.h oscctrl.h rtc.h tc3.h sercom3.h sercom5.h dmac.h sercom1.h wdt.h mclk.h trng.h gclk.h ac.h mtb.h evsys.h pac.h eic.h supc.h port.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../utils/cmsis/saml22/include/component/: mtb.h adc.h aes.h rstc.h dsu.h port.h eic.h ccl.h tal.h slcd.h oscctrl.h evsys.h usb.h pac.h tcc.h supc.h osc32kctrl.h tc.h gclk.h nvmctrl.h mclk.h wdt.h dmac.h freqm.h sercom.h rtc.h pm.h trng.h ac.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
