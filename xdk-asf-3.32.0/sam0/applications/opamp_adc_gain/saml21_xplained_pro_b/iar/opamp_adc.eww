<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\opamp_adc_flash.ewp</path>
	</project>
</workspace>
