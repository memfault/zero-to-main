<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\slcd_features_flash.ewp</path>
	</project>
</workspace>
