<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\adc_configurations_example_flash.ewp</path>
	</project>
</workspace>
