<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\waveform_generator_flash.ewp</path>
	</project>
</workspace>
