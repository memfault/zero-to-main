<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\dac_sound_player_flash.ewp</path>
	</project>
</workspace>
