<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xosc32k_fail_detector_flash.ewp</path>
	</project>
</workspace>
