<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\clock_fail_detector_flash.ewp</path>
	</project>
</workspace>
