<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ccl_example_flash.ewp</path>
	</project>
</workspace>
