<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ac_examples_flash.ewp</path>
	</project>
</workspace>
