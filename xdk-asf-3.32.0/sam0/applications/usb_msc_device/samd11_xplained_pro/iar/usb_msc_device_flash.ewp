# IAR project usb_msc_device_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; SPI_CALLBACK_MODE=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__; SYSTICK_MODE
  ICCARM.CCIncludePath2: ..; ../../../../drivers/system/power; ../../../../drivers/system/reset; ../..; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../drivers/system/clock/clock_samd09_d10_d11; ../../../../drivers/sercom/spi; ../../../../boards/samd11_xplained_pro; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../drivers/system/reset/reset_sam_d_r; ../../../../../common/utils; ../../../../utils/cmsis/samd11/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../utils/cmsis/samd11/include; ../../../../../common2/services/delay/sam0; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../../common2/components/memory/sd_mmc; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_msc_device_flash.bin
  ILINK.IlinkOutputFile: usb_msc_device_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/applications/usb_msc_device
    ../../: usb_msc.c main.c usb_descriptor.h scsi_commands.h usb_msc.h
  group sam0/applications/usb_msc_device/samd11_xplained_pro
    ../: conf_board.h conf_sd_mmc.h conf_spi.h conf_clocks.h
  group sam0/applications/usb_msc_device/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd09_d10_d11
    ../../../../drivers/system/clock/clock_samd09_d10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../drivers/sercom/spi/: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/boards/samd11_xplained_pro
    ../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd11/source
    ../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../utils/cmsis/samd11/include/: samd11d14au.h samd11d14as.h samd11d14am.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../utils/cmsis/samd11/include/component/: adc.h gclk.h ac.h nvmctrl.h dsu.h wdt.h tcc.h dac.h mtb.h tc.h sercom.h hmatrixb.h evsys.h dmac.h pac.h sysctrl.h pm.h eic.h port.h usb.h rtc.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../utils/cmsis/samd11/include/instance/: sercom1.h nvmctrl.h wdt.h dsu.h pac1.h pac2.h dmac.h evsys.h gclk.h dac.h sbmatrix.h adc.h tcc0.h pac0.h tc2.h ac.h usb.h sysctrl.h sercom0.h sercom2.h tc1.h rtc.h mtb.h pm.h port.h eic.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11d14as.h samd11d14au.h samd11c14a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrecursion.h stringz.h mrepeat.h preprocessor.h
  group common2/components/memory/sd_mmc
    ../../../../../common2/components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc.c sd_mmc_protocol.h sd_mmc_spi.h sd_mmc.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
