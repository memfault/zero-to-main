<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tcc_examples_flash.ewp</path>
	</project>
</workspace>
