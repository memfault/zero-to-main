<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_master_bootloader_flash.ewp</path>
	</project>
</workspace>
