# IAR project samba_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; USART_CALLBACK_MODE=true; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../drivers/system/interrupt; ../../../../../common/services/usb/class/cdc/device; ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../utils/cmsis/saml22/include; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/sleepmgr; ../../../../utils/cmsis/saml22/source; ../../../../../common/services/usb/class/cdc; ../../../../drivers/system/power/power_sam_l; ../../../../drivers/usb/usb_sam_l; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/system/interrupt/system_interrupt_saml22; ../../../../../common/utils; ../../../../drivers/extint/extint_sam_l_c; ..; ../../../../drivers/usb/stack_interface; ../..; ../../../../drivers/system/clock/clock_saml22; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/usb; ../../../../drivers/system; ../../../../drivers/extint; ../../../../utils/header_files; ../../../../boards/saml22_xplained_pro; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: samba_bootloader_flash.bin
  ILINK.IlinkOutputFile: samba_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../common/services/sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udd.h udi.h udc_desc.h udc.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../drivers/system/clock/clock_saml22/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/usb
    ../../../../drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../drivers/usb/usb_sam_l/: usb.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/applications/samba_bootloader
    ../../: sam_ba_monitor.c usart_sam_ba.c main.c sam_ba_monitor.h main.h usart_sam_ba.h
  group sam0/applications/samba_bootloader/saml22_xplained_pro
    ../: conf_board.h conf_bootloader.h conf_usb.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group sam0/applications/samba_bootloader/saml22_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../utils/cmsis/saml22/include/: saml22n17a.h saml22n16a.h saml22g17a.h saml22.h saml22j17a.h saml22g18a.h saml22j16a.h saml22j18a.h saml22n18a.h saml22g16a.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../utils/cmsis/saml22/include/component/: mclk.h ac.h aes.h wdt.h evsys.h gclk.h slcd.h tc.h supc.h rtc.h pac.h adc.h mtb.h rstc.h eic.h ccl.h usb.h trng.h dsu.h pm.h tcc.h tal.h dmac.h port.h nvmctrl.h sercom.h oscctrl.h freqm.h osc32kctrl.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../utils/cmsis/saml22/include/instance/: rstc.h pac.h sercom3.h nvmctrl.h trng.h sercom5.h mclk.h wdt.h usb.h gclk.h port.h eic.h tal.h tc1.h dmac.h evsys.h tc2.h pm.h ac.h tc0.h supc.h mtb.h adc.h slcd.h sercom0.h freqm.h tc3.h ccl.h aes.h sercom2.h sercom4.h rtc.h dsu.h oscctrl.h osc32kctrl.h sercom1.h tcc0.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../utils/cmsis/saml22/include/pio/: saml22j18a.h saml22g18a.h saml22n16a.h saml22g16a.h saml22n17a.h saml22j16a.h saml22g17a.h saml22j17a.h saml22n18a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/boards/saml22_xplained_pro
    ../../../../boards/saml22_xplained_pro/: board_init.c saml22_xplained_pro.h
