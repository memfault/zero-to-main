# IAR project samba_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UDD_ENABLE; EXTINT_CALLBACK_MODE=true; __SAML21J18A__; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; USART_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/system/interrupt; ../../../../../common/services/usb/class/cdc/device; ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../drivers/system/interrupt/system_interrupt_saml21; ..; ../../../../utils/preprocessor; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/usb/class/cdc; ../../../../drivers/system/power/power_sam_l; ../../../../drivers/usb/usb_sam_l; ../../../../utils/header_files; ../../../../../common/services/usb; ../../../../boards/saml21_xplained_pro; ../../../../drivers/extint/extint_sam_l_c; ../../../../drivers/usb/stack_interface; ../../../../../common/services/usb/udc; ../../../../utils/cmsis/saml21/include; ../../../../drivers/system/clock/clock_saml21; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../..; ../../../../drivers/system; ../../../../drivers/extint; ../../../../utils/cmsis/saml21/source; ../../../../drivers/usb; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: samba_bootloader_flash.bin
  ILINK.IlinkOutputFile: samba_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/usb
    ../../../../drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../drivers/usb/usb_sam_l/: usb.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/applications/samba_bootloader
    ../../: sam_ba_monitor.c usart_sam_ba.c main.c sam_ba_monitor.h main.h usart_sam_ba.h
  group sam0/applications/samba_bootloader/saml21_xplained_pro
    ../: conf_bootloader.h conf_board.h conf_usb.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group sam0/applications/samba_bootloader/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/saml21_xplained_pro
    ../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21g18a.h saml21j18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../utils/cmsis/saml21/include/component/: trng.h ccl.h adc_100.h eic_100.h rtc_100.h nvmctrl_301.h sercom.h pac_100.h port.h wdt.h rstc_100.h dac.h mtb.h dsu.h oscctrl.h tc_100.h tal.h ac.h pm_100.h osc32kctrl.h tcc_200.h mclk_100.h opamp.h evsys.h supc_100.h usb.h gclk_100.h dmac.h aes.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../utils/cmsis/saml21/include/instance/: trng.h mtb.h sercom2.h dmac.h pm_100.h ac.h evsys.h opamp.h gclk_100.h nvmctrl_301.h tcc2_200.h aes.h dac.h dsu.h tc0_100.h port.h sercom4.h tc4_100.h adc_100.h rstc_100.h tcc0_200.h ccl.h pac_100.h wdt.h sercom1.h tc2_100.h tal.h supc_100.h tcc1_200.h rtc_100.h oscctrl.h sercom3.h sercom5.h tc1_100.h usb.h sercom0.h osc32kctrl.h tc3_100.h mclk_100.h eic_100.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../utils/cmsis/saml21/include/pio/: saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../common/services/sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udd.h udc_desc.h udi.h udc.h
  group common/boards
    ../../../../../common/boards/: board.h
