<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\samba_bootloader_flash.ewp</path>
	</project>
</workspace>
