# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD10D14AM Atmel ATSAMD10D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; BOARD=SAMD10_XPLAINED_MINI; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMD10D14AM__
  ICCARM.CCIncludePath2: ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../boards/samd10_xplained_mini; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../drivers/system/clock/clock_samd09_d10_d11; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../../../../utils/cmsis/samd10/include; ../..; ../../../../drivers/system/reset/reset_sam_d_r; ../../../../../common/utils; ../../../../drivers/extint/extint_sam_d_r; ..; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/tc; ../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../utils/cmsis/samd10/source; ../../../../../common2/services/delay/sam0; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/extint; ../../../../utils/header_files; ../../../../drivers/system/clock; ../../../../utils/stdio/stdio_serial; ../../../../drivers/tc/tc_sam_d_r; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd10/iar/samd10d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r
    ../../../../drivers/tc/tc_sam_d_r/: tc.c
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r
    ../../../../drivers/extint/extint_sam_d_r/: extint.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd09_d10_d11
    ../../../../drivers/system/clock/clock_samd09_d10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd10/source
    ../../../../utils/cmsis/samd10/source/: system_samd10.c system_samd10.h
  group sam0/utils/cmsis/samd10/source/iar
    ../../../../utils/cmsis/samd10/source/iar/: startup_samd10.c
  group sam0/utils/cmsis/samd10/include
    ../../../../utils/cmsis/samd10/include/: samd10c13a.h samd10c12a.h samd10d14au.h samd10d14as.h samd10c14a.h samd10d13am.h samd10d12am.h samd10d13as.h samd10.h samd10d12as.h samd10d14am.h
  group sam0/utils/cmsis/samd10/include/instance
    ../../../../utils/cmsis/samd10/include/instance/: ac.h dmac.h tcc0.h adc.h mtb.h pac0.h dsu.h nvmctrl.h sercom1.h tc1.h pm.h wdt.h evsys.h dac.h tc2.h sysctrl.h port.h rtc.h eic.h sercom0.h sercom2.h pac1.h sbmatrix.h gclk.h pac2.h
  group sam0/utils/cmsis/samd10/include/pio
    ../../../../utils/cmsis/samd10/include/pio/: samd10d13as.h samd10c13a.h samd10d14am.h samd10d14au.h samd10d14as.h samd10d13am.h samd10d12am.h samd10c12a.h samd10d12as.h samd10c14a.h
  group sam0/utils/cmsis/samd10/include/component
    ../../../../utils/cmsis/samd10/include/component/: hmatrixb.h dsu.h port.h dmac.h mtb.h eic.h tc.h pac.h dac.h adc.h ac.h gclk.h nvmctrl.h wdt.h tcc.h pm.h evsys.h rtc.h sysctrl.h sercom.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam0/applications/getting-started
    ../../: main.c
  group sam0/applications/getting-started/samd10d14a_samd10_xplained_mini
    ../: conf_uart_serial.h conf_board.h conf_clocks.h conf_extint.h
  group sam0/applications/getting-started/samd10d14a_samd10_xplained_mini/iar
    ./: asf.h
  group sam0/boards/samd10_xplained_mini
    ../../../../boards/samd10_xplained_mini/: board_init.c samd10_xplained_mini.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
