# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAML21J18B__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../boards/saml21_xplained_pro_b; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../../../../utils/cmsis/saml21/include_b; ../..; ../../../../drivers/tc/tc_sam_l_c; ../../../../../common/utils; ..; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ../../../../drivers/tc; ../../../../utils/cmsis/saml21/source; ../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../drivers/extint/extint_sam_l_c; ../../../../../common2/services/delay/sam0; ../../../../drivers/system/clock/clock_saml21; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/extint; ../../../../utils/header_files; ../../../../utils/stdio/stdio_serial; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../utils/cmsis/saml21/include_b/: saml21g18b.h saml21e18b.h saml21g17b.h saml21j18b.h saml21g16b.h saml21.h saml21j17b.h saml21e15b.h saml21e17b.h saml21j16b.h saml21e16b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../utils/cmsis/saml21/include_b/instance/: mtb.h opamp.h tc4.h tc0.h dmac.h dsu.h osc32kctrl.h tc2.h sercom5.h tcc0.h wdt.h pac.h nvmctrl.h ac.h trng.h tcc1.h oscctrl.h ccl.h sercom2.h gclk.h adc.h rtc.h tcc2.h tc1.h supc.h evsys.h sercom3.h eic.h pm.h sercom0.h tal.h usb.h dac.h aes.h sercom4.h port.h sercom1.h tc3.h rstc.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../utils/cmsis/saml21/include_b/component/: wdt.h adc.h rstc.h supc.h opamp.h pac.h mtb.h tc.h port.h evsys.h aes.h trng.h mclk.h dac.h ccl.h dmac.h sercom.h dsu.h pm.h nvmctrl.h oscctrl.h osc32kctrl.h tcc.h tal.h eic.h rtc.h ac.h usb.h gclk.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../utils/cmsis/saml21/include_b/pio/: saml21e17b.h saml21j16b.h saml21g17b.h saml21e16b.h saml21e18b.h saml21g16b.h saml21j17b.h saml21g18b.h saml21e15b.h saml21j18b.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/applications/getting-started
    ../../: main.c
  group sam0/applications/getting-started/saml21j18b_saml21_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_extint.h conf_clocks.h
  group sam0/applications/getting-started/saml21j18b_saml21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
