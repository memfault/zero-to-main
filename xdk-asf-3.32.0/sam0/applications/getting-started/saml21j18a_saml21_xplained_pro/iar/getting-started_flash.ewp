# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; __SAML21J18A__; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/port; ../../../../drivers/system/reset; ..; ../../../../boards/saml21_xplained_pro; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../..; ../../../../drivers/tc/tc_sam_l_c; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ../../../../drivers/tc; ../../../../utils/cmsis/saml21/source; ../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../drivers/extint/extint_sam_l_c; ../../../../../common2/services/delay/sam0; ../../../../utils/cmsis/saml21/include; ../../../../drivers/system/clock/clock_saml21; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/extint; ../../../../utils/header_files; ../../../../utils/stdio/stdio_serial; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21g18a.h saml21j18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../utils/cmsis/saml21/include/component/: trng.h ccl.h adc_100.h eic_100.h rtc_100.h osc32kctrl.h nvmctrl_301.h sercom.h pac_100.h port.h wdt.h rstc_100.h dac.h mtb.h dsu.h oscctrl.h tc_100.h tal.h ac.h pm_100.h tcc_200.h mclk_100.h opamp.h evsys.h supc_100.h usb.h gclk_100.h dmac.h aes.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../utils/cmsis/saml21/include/instance/: trng.h mtb.h sercom2.h dmac.h pm_100.h ac.h opamp.h gclk_100.h nvmctrl_301.h tcc2_200.h dac.h dsu.h port.h sercom4.h tc4_100.h adc_100.h rstc_100.h tcc0_200.h ccl.h pac_100.h wdt.h sercom1.h eic_100.h tc2_100.h tal.h evsys.h aes.h supc_100.h tcc1_200.h rtc_100.h oscctrl.h sercom3.h sercom5.h tc1_100.h tc0_100.h usb.h sercom0.h osc32kctrl.h tc3_100.h mclk_100.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../utils/cmsis/saml21/include/pio/: saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/saml21_xplained_pro
    ../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/applications/getting-started
    ../../: main.c
  group sam0/applications/getting-started/saml21j18a_saml21_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_clocks.h conf_extint.h
  group sam0/applications/getting-started/saml21j18a_saml21_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
