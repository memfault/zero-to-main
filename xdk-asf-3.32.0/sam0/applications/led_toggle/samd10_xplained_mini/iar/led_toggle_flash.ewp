# IAR project led_toggle_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD10D14AM Atmel ATSAMD10D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMD10_XPLAINED_MINI; __SAMD10D14AM__
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../boards/samd10_xplained_mini; ../../../../utils/preprocessor; ../../../../drivers/system/clock/clock_samd09_d10_d11; ../../../../utils; ../../../../drivers/port; ../../../../boards; ../../../../utils/cmsis/samd10/include; ../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../..; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/system/reset/reset_sam_d_r; ../../../../utils/cmsis/samd10/source; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ..; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: led_toggle_flash.bin
  ILINK.IlinkOutputFile: led_toggle_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd10/iar/samd10d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd09_d10_d11
    ../../../../drivers/system/clock/clock_samd09_d10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd10/source
    ../../../../utils/cmsis/samd10/source/: system_samd10.c system_samd10.h
  group sam0/utils/cmsis/samd10/source/iar
    ../../../../utils/cmsis/samd10/source/iar/: startup_samd10.c
  group sam0/utils/cmsis/samd10/include
    ../../../../utils/cmsis/samd10/include/: samd10c13a.h samd10c12a.h samd10d14au.h samd10d14as.h samd10c14a.h samd10d13am.h samd10d12am.h samd10d13as.h samd10.h samd10d12as.h samd10d14am.h
  group sam0/utils/cmsis/samd10/include/pio
    ../../../../utils/cmsis/samd10/include/pio/: samd10d13as.h samd10c13a.h samd10d14am.h samd10d14au.h samd10d14as.h samd10d13am.h samd10d12am.h samd10c12a.h samd10d12as.h samd10c14a.h
  group sam0/utils/cmsis/samd10/include/component
    ../../../../utils/cmsis/samd10/include/component/: hmatrixb.h dsu.h port.h dmac.h sysctrl.h mtb.h eic.h tc.h pac.h dac.h adc.h ac.h gclk.h nvmctrl.h wdt.h tcc.h pm.h evsys.h rtc.h sercom.h
  group sam0/utils/cmsis/samd10/include/instance
    ../../../../utils/cmsis/samd10/include/instance/: dmac.h tcc0.h adc.h mtb.h pac0.h dsu.h nvmctrl.h sercom1.h port.h pm.h wdt.h evsys.h dac.h tc2.h sysctrl.h tc1.h rtc.h eic.h sercom0.h sercom2.h pac1.h sbmatrix.h gclk.h pac2.h ac.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam0/applications/led_toggle
    ../../: led_toggle.c
  group sam0/applications/led_toggle/samd10_xplained_mini
    ../: conf_board.h conf_clocks.h
  group sam0/applications/led_toggle/samd10_xplained_mini/iar
    ./: asf.h
  group sam0/boards/samd10_xplained_mini
    ../../../../boards/samd10_xplained_mini/: board_init.c samd10_xplained_mini.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
