<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\led_toggle_flash.ewp</path>
	</project>
</workspace>
