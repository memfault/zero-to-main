<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\spi_slave_bootloader_flash.ewp</path>
	</project>
</workspace>
