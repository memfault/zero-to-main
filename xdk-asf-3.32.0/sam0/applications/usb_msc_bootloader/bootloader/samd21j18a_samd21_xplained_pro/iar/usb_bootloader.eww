<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\usb_bootloader_flash.ewp</path>
	</project>
</workspace>
