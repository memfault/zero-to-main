<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tcc_features_flash.ewp</path>
	</project>
</workspace>
