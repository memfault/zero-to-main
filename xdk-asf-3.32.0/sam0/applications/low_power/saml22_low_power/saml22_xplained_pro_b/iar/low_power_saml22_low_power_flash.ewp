# IAR project low_power_saml22_low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO_B; RTC_COUNT_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=false; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../../drivers/system/power; ../../../../../drivers/system/reset; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/saml22/include; ../../../../../drivers/rtc/rtc_sam_l_c; ../../../../../utils; ../../../../../drivers/sercom; ../../../../../drivers/port; ../../../../../boards; ../../../../../drivers/sercom/usart; ../../../../../../common/services/serial; ../../../../../drivers/rtc; ../../../../../utils/cmsis/saml22/source; ../../../../../drivers/system/interrupt; ../../../../../drivers/system/power/power_sam_l; ..; ../../../../../boards/saml22_xplained_pro_b; ../../../../../drivers/system/interrupt/system_interrupt_saml22; ../../../../../../common/utils; ../../../../../drivers/extint/extint_sam_l_c; ../..; ../../../../../drivers/system/clock/clock_saml22; ../../../../../../common/boards; ../../../../../drivers/system/reset/reset_sam_l; ../../../../../drivers/system/pinmux; ../../../../../drivers/system; ../../../../../drivers/extint; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_saml22_low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_saml22_low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/rtc
    ../../../../../drivers/rtc/: rtc_tamper.h rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../drivers/rtc/rtc_sam_l_c/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/extint
    ../../../../../drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/system
    ../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../drivers/system/clock/clock_saml22/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../utils/cmsis/saml22/include/: saml22g16a.h saml22j18a.h saml22g18a.h saml22.h saml22j16a.h saml22n18a.h saml22n17a.h saml22n16a.h saml22g17a.h saml22j17a.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../utils/cmsis/saml22/include/component/: adc.h supc.h rtc.h port.h tc.h mclk.h aes.h ac.h evsys.h eic.h pac.h usb.h pm.h wdt.h tal.h sercom.h trng.h freqm.h rstc.h oscctrl.h gclk.h osc32kctrl.h ccl.h mtb.h dsu.h tcc.h dmac.h nvmctrl.h slcd.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../utils/cmsis/saml22/include/instance/: pac.h evsys.h pm.h supc.h aes.h dsu.h tc0.h sercom3.h sercom1.h tc3.h rtc.h mclk.h sercom5.h slcd.h eic.h tc1.h sercom0.h nvmctrl.h usb.h rstc.h tc2.h osc32kctrl.h tcc0.h sercom4.h sercom2.h gclk.h dmac.h freqm.h trng.h port.h wdt.h ac.h tal.h ccl.h adc.h oscctrl.h mtb.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../utils/cmsis/saml22/include/pio/: saml22j17a.h saml22g16a.h saml22n16a.h saml22j18a.h saml22n17a.h saml22g18a.h saml22g17a.h saml22n18a.h saml22j16a.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group sam0/applications/low_power/saml22_low_power
    ../../: low_power_demo.c
  group sam0/applications/low_power/saml22_low_power/saml22_xplained_pro_b
    ../: conf_rtc.h conf_board.h conf_app.h conf_clocks.h conf_extint.h
  group sam0/applications/low_power/saml22_low_power/saml22_xplained_pro_b/iar
    ./: asf.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
