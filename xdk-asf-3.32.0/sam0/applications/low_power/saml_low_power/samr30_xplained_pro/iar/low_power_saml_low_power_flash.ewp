# IAR project low_power_saml_low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; ADC_CALLBACK_MODE=true; CYCLE_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; USART_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../../../../drivers/system/power; ../../../../../utils/cmsis/samr30/source; ../../../../../drivers/adc; ../../../../../drivers/rtc/rtc_sam_l_c; ../../../../../utils/preprocessor; ../../../../../drivers/dma; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../../drivers/sercom; ../../../../../drivers/port; ../../../../../boards; ../../../../../drivers/sercom/usart; ../../../../../../common/services/serial; ../../../../../drivers/events/events_sam_l_c; ../../../../../drivers/system/reset; ..; ../../../../../drivers/tc/tc_sam_l_c; ../../../../../drivers/rtc; ../../../../../../common/utils; ../../../../../boards/samr30_xplained_pro; ../../../../../drivers/system/interrupt; ../../../../../drivers/system/power/power_sam_l; ../..; ../../../../../drivers/tc; ../../../../../drivers/system/interrupt/system_interrupt_samr30; ../../../../../utils/cmsis/samr30/include; ../../../../../drivers/extint/extint_sam_l_c; ../../../../../../common2/services/delay/sam0; ../../../../../drivers/events; ../../../../../../common/boards; ../../../../../drivers/system/reset/reset_sam_l; ../../../../../drivers/system/pinmux; ../../../../../drivers/system; ../../../../../drivers/adc/adc_sam_l_c; ../../../../../drivers/extint; ../../../../../drivers/system/clock/clock_samr30; ../../../../../utils/header_files; ../../../../../utils/stdio/stdio_serial; ../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_saml_low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_saml_low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../drivers/system/clock/clock_samr30/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/events
    ../../../../../drivers/events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../../drivers/events/events_sam_l_c/: events.c
  group sam0/drivers/extint
    ../../../../../drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/dma
    ../../../../../drivers/dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../../drivers/dma/quick_start/: qs_dma_basic.h
  group sam0/drivers/port
    ../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/tc
    ../../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/adc
    ../../../../../drivers/adc/: adc_callback.h adc.h
  group sam0/drivers/adc/adc_sam_l_c
    ../../../../../drivers/adc/adc_sam_l_c/: adc.c adc_callback.c adc_feature.h
  group sam0/drivers/rtc
    ../../../../../drivers/rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../drivers/rtc/rtc_sam_l_c/: rtc_count.c
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../utils/cmsis/samr30/include/: samr30g18a.h samr30.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../utils/cmsis/samr30/include/component/: eic.h supc.h ac.h wdt.h tc.h mtb.h dsu.h adc.h rfctrl.h tal.h sercom.h pm.h evsys.h osc32kctrl.h ccl.h dmac.h pac.h rtc.h port.h rstc.h nvmctrl.h usb.h tcc.h oscctrl.h mclk.h gclk.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../utils/cmsis/samr30/include/instance/: mclk.h supc.h tcc0.h tc1.h ac.h pm.h oscctrl.h gclk.h port.h rstc.h wdt.h ccl.h sercom1.h dmac.h adc.h sercom0.h tcc2.h nvmctrl.h rfctrl.h rtc.h evsys.h pac.h tc4.h usb.h sercom4.h osc32kctrl.h tcc1.h tc0.h sercom3.h tal.h mtb.h eic.h sercom5.h dsu.h sercom2.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/applications/low_power/saml_low_power
    ../../: low_power_demo.c
  group sam0/applications/low_power/saml_low_power/samr30_xplained_pro
    ../: conf_rtc.h conf_board.h conf_app.h conf_dma.h conf_clocks.h conf_extint.h
  group sam0/applications/low_power/saml_low_power/samr30_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
