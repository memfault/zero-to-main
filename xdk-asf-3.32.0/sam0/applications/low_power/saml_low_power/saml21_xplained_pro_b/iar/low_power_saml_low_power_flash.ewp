# IAR project low_power_saml_low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; CYCLE_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; __SAML21J18B__; USART_CALLBACK_MODE=false; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../drivers/system/power; ../../../../../drivers/system/reset; ..; ../../../../../drivers/rtc/rtc_sam_l_c; ../../../../../utils/preprocessor; ../../../../../drivers/dma; ../../../../../boards/saml21_xplained_pro_b; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../../drivers/sercom; ../../../../../drivers/port; ../../../../../boards; ../../../../../drivers/sercom/usart; ../../../../../../common/services/serial; ../../../../../utils/cmsis/saml21/include_b; ../../../../../drivers/events/events_sam_l_c; ../../../../../drivers/adc; ../../../../../drivers/tc/tc_sam_l_c; ../../../../../drivers/rtc; ../../../../../../common/utils; ../../../../../drivers/system/interrupt; ../../../../../drivers/system/power/power_sam_l; ../..; ../../../../../drivers/tc; ../../../../../utils/header_files; ../../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../../drivers/extint/extint_sam_l_c; ../../../../../../common2/services/delay/sam0; ../../../../../drivers/system/clock/clock_saml21; ../../../../../../common/boards; ../../../../../drivers/system/reset/reset_sam_l; ../../../../../drivers/system/pinmux; ../../../../../drivers/system; ../../../../../drivers/adc/adc_sam_l_c; ../../../../../drivers/extint; ../../../../../drivers/events; ../../../../../utils/cmsis/saml21/source; ../../../../../utils/stdio/stdio_serial; ../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_saml_low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_saml_low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/tc
    ../../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/extint
    ../../../../../drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/dma
    ../../../../../drivers/dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../../drivers/dma/quick_start/: qs_dma_basic.h
  group sam0/drivers/port
    ../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/adc
    ../../../../../drivers/adc/: adc_callback.h adc.h
  group sam0/drivers/adc/adc_sam_l_c
    ../../../../../drivers/adc/adc_sam_l_c/: adc.c adc_callback.c adc_feature.h
  group sam0/drivers/events
    ../../../../../drivers/events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../../drivers/events/events_sam_l_c/: events.c
  group sam0/drivers/rtc
    ../../../../../drivers/rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../drivers/rtc/rtc_sam_l_c/: rtc_count.c
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../utils/cmsis/saml21/include_b/: saml21j16b.h saml21.h saml21e18b.h saml21e17b.h saml21g18b.h saml21j17b.h saml21e15b.h saml21j18b.h saml21e16b.h saml21g16b.h saml21g17b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../utils/cmsis/saml21/include_b/instance/: tc3.h aes.h pm.h supc.h tc1.h dac.h tal.h mtb.h oscctrl.h gclk.h rstc.h port.h tc2.h tcc1.h tc0.h tcc2.h sercom3.h trng.h tc4.h sercom1.h mclk.h pac.h usb.h evsys.h ccl.h tcc0.h ac.h adc.h sercom2.h nvmctrl.h osc32kctrl.h sercom0.h eic.h wdt.h sercom5.h dmac.h rtc.h dsu.h opamp.h sercom4.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../utils/cmsis/saml21/include_b/component/: oscctrl.h aes.h pm.h supc.h pac.h trng.h rstc.h osc32kctrl.h tcc.h mtb.h ccl.h evsys.h dmac.h usb.h ac.h adc.h port.h dac.h gclk.h dsu.h opamp.h tal.h eic.h tc.h sercom.h wdt.h nvmctrl.h rtc.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../utils/cmsis/saml21/include_b/pio/: saml21j16b.h saml21g17b.h saml21j18b.h saml21e17b.h saml21g16b.h saml21j17b.h saml21e16b.h saml21g18b.h saml21e18b.h saml21e15b.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/applications/low_power/saml_low_power
    ../../: low_power_demo.c
  group sam0/applications/low_power/saml_low_power/saml21_xplained_pro_b
    ../: conf_rtc.h conf_board.h conf_app.h conf_dma.h conf_clocks.h conf_extint.h
  group sam0/applications/low_power/saml_low_power/saml21_xplained_pro_b/iar
    ./: asf.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
