<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\low_power_saml_low_power_flash.ewp</path>
	</project>
</workspace>
