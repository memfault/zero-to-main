# IAR project tictactoe_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; ARM_MATH_CM0PLUS=true; __SAML21J18A__; SPI_CALLBACK_MODE=false; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../../common2/services/gfx_mono; ../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../drivers/sercom/spi; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../../common2/components/display/ssd1306; ..; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ../../../../utils/header_files; ../../../../boards/saml21_xplained_pro; ../../../../../common2/services/delay/sam0; ../..; ../../../../utils/cmsis/saml21/include; ../../../../drivers/system/clock/clock_saml21; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/cmsis/saml21/source; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tictactoe_flash.bin
  ILINK.IlinkOutputFile: tictactoe_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/boards/saml21_xplained_pro
    ../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21g18a.h saml21j18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../utils/cmsis/saml21/include/component/: trng.h ccl.h eic_100.h rtc_100.h nvmctrl_301.h sercom.h pac_100.h port.h wdt.h rstc_100.h dac.h mtb.h dsu.h adc_100.h oscctrl.h tc_100.h tal.h ac.h pm_100.h osc32kctrl.h tcc_200.h mclk_100.h opamp.h evsys.h supc_100.h usb.h gclk_100.h dmac.h aes.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../utils/cmsis/saml21/include/instance/: trng.h mtb.h sercom2.h sercom4.h dmac.h pm_100.h ac.h evsys.h opamp.h gclk_100.h nvmctrl_301.h tcc2_200.h dac.h dsu.h port.h tc4_100.h adc_100.h rstc_100.h tcc0_200.h ccl.h pac_100.h wdt.h sercom1.h eic_100.h tc2_100.h tal.h aes.h supc_100.h tcc1_200.h rtc_100.h oscctrl.h sercom3.h sercom5.h tc1_100.h tc0_100.h usb.h sercom0.h osc32kctrl.h tc3_100.h mclk_100.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../utils/cmsis/saml21/include/pio/: saml21j18a.h saml21g18a.h saml21e18a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrecursion.h mrepeat.h preprocessor.h stringz.h
  group sam0/applications/tictactoe
    ../../: tictactoe.c
  group sam0/applications/tictactoe/saml21_xplained_pro
    ../: conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h conf_sysfont.h
  group sam0/applications/tictactoe/saml21_xplained_pro/iar
    ./: asf.h
  group common2/services/gfx_mono
    ../../../../../common2/services/gfx_mono/: sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_text.c gfx_mono_generic.h sysfont.h gfx_mono_framebuffer.h gfx_mono.h gfx_mono_text.h gfx_mono_ug_2832hsweg04.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
