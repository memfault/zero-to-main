# IAR project tictactoe_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; SPI_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../utils/cmsis/samr30/source; ../../../../../common2/services/gfx_mono; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../drivers/sercom/spi; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../../common2/components/display/ssd1306; ../../../../drivers/system/reset; ../../../../../common/utils; ../../../../boards/samr30_xplained_pro; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ..; ../../../../drivers/system/interrupt/system_interrupt_samr30; ../../../../utils/cmsis/samr30/include; ../../../../../common2/services/delay/sam0; ../..; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/system/clock/clock_samr30; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tictactoe_flash.bin
  ILINK.IlinkOutputFile: tictactoe_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/gfx_mono
    ../../../../../common2/services/gfx_mono/: sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_text.c gfx_mono_generic.h sysfont.h gfx_mono.h gfx_mono_framebuffer.h gfx_mono_text.h gfx_mono_ug_2832hsweg04.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../drivers/system/clock/clock_samr30/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../utils/cmsis/samr30/include/: samr30.h samr30g18a.h samr30e18a.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../utils/cmsis/samr30/include/instance/: rtc.h tc4.h pac.h evsys.h adc.h ac.h oscctrl.h tc0.h sercom1.h tcc0.h osc32kctrl.h gclk.h port.h tcc2.h rfctrl.h mtb.h sercom3.h sercom5.h dmac.h nvmctrl.h sercom0.h pm.h tal.h tcc1.h rstc.h eic.h sercom2.h sercom4.h dsu.h supc.h usb.h mclk.h tc1.h ccl.h wdt.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../utils/cmsis/samr30/include/component/: nvmctrl.h ac.h gclk.h supc.h sercom.h mclk.h wdt.h evsys.h dsu.h usb.h rtc.h dmac.h eic.h ccl.h tal.h pm.h mtb.h rstc.h port.h tc.h adc.h tcc.h oscctrl.h pac.h rfctrl.h osc32kctrl.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../utils/cmsis/samr30/include/pio/: samr30e18a.h samr30g18a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrecursion.h mrepeat.h preprocessor.h stringz.h
  group sam0/boards/samr30_xplained_pro
    ../../../../boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/applications/tictactoe
    ../../: tictactoe.c
  group sam0/applications/tictactoe/samr30_xplained_pro
    ../: conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h conf_sysfont.h
  group sam0/applications/tictactoe/samr30_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
