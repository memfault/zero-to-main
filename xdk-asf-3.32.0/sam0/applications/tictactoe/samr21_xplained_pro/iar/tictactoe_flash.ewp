# IAR project tictactoe_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; SPI_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../drivers/system/interrupt/system_interrupt_samr21; ../../../../utils/preprocessor; ../../../../utils/cmsis/samr21/source; ../../../../../common2/services/delay; ../../../../drivers/sercom/spi; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../../common2/components/display/ssd1306; ../../../../../common2/services/gfx_mono; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/system/reset/reset_sam_d_r; ..; ../../../../../common2/services/delay/sam0; ../..; ../../../../boards/samr21_xplained_pro; ../../../../utils/cmsis/samr21/include; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ../../../../drivers/system/clock; ../../../../drivers/system/clock/clock_samd21_r21_da; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tictactoe_flash.bin
  ILINK.IlinkOutputFile: tictactoe_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/gfx_mono
    ../../../../../common2/services/gfx_mono/: sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_text.c gfx_mono_generic.h sysfont.h gfx_mono.h gfx_mono_framebuffer.h gfx_mono_text.h gfx_mono_ug_2832hsweg04.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group sam0/boards/samr21_xplained_pro
    ../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../drivers/system/clock/clock_samd21_r21_da/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/applications/tictactoe
    ../../: tictactoe.c
  group sam0/applications/tictactoe/samr21_xplained_pro
    ../: conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h conf_sysfont.h
  group sam0/applications/tictactoe/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../utils/cmsis/samr21/include/: samr21.h samr21g17a.h samr21g18a.h samr21e17a.h samr21e19a.h samr21e16a.h samr21e18a.h samr21g16a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../utils/cmsis/samr21/include/instance/: sbmatrix.h evsys.h tcc1.h eic.h pac2.h adc.h rfctrl.h sercom1.h sercom5.h dmac.h tc5.h tc3.h pm.h sercom3.h port.h wdt.h ac.h usb.h tcc2.h sercom0.h pac0.h tc4.h dsu.h tcc0.h sercom2.h sercom4.h rtc.h pac1.h mtb.h gclk.h sysctrl.h nvmctrl.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../utils/cmsis/samr21/include/component/: tcc.h hmatrixb.h usb.h nvmctrl.h rtc.h port.h tc.h mtb.h dmac.h ac.h wdt.h dsu.h evsys.h rfctrl.h sercom.h adc.h sysctrl.h pm.h pac.h eic.h gclk.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../utils/cmsis/samr21/include/pio/: samr21e17a.h samr21g17a.h samr21g18a.h samr21g16a.h samr21e18a.h samr21e16a.h samr21e19a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h stringz.h preprocessor.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
