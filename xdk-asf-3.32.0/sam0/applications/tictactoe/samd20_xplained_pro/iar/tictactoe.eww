<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tictactoe_flash.ewp</path>
	</project>
</workspace>
