# IAR project sleepwalking_adc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; SYSTICK_MODE; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; __SAML21J18B__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../drivers/adc; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/rtc/rtc_sam_l_c; ../../../../utils/preprocessor; ../../../../boards/saml21_xplained_pro_b; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/port; ../../../../boards; ../../../../utils/cmsis/saml21/include_b; ../../../../drivers/events/events_sam_l_c; ../../../../drivers/rtc; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ..; ../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../../common2/services/delay/sam0; ../../../../drivers/system/clock/clock_saml21; ../../../../../common/boards; ../..; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/adc/adc_sam_l_c; ../../../../drivers/events; ../../../../utils/cmsis/saml21/source; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepwalking_adc_flash.bin
  ILINK.IlinkOutputFile: sleepwalking_adc_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/adc
    ../../../../drivers/adc/: adc_callback.h adc.h
  group sam0/drivers/adc/adc_sam_l_c
    ../../../../drivers/adc/adc_sam_l_c/: adc.c adc_callback.c adc_feature.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../drivers/rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../drivers/rtc/rtc_sam_l_c/: rtc_count.c
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../drivers/events/events_sam_l_c/: events.c
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../utils/cmsis/saml21/include_b/: saml21g18b.h saml21e18b.h saml21g17b.h saml21j18b.h saml21g16b.h saml21.h saml21j17b.h saml21e15b.h saml21e17b.h saml21j16b.h saml21e16b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../utils/cmsis/saml21/include_b/instance/: mtb.h opamp.h tc4.h tc0.h dmac.h dsu.h osc32kctrl.h tc2.h sercom5.h tcc0.h wdt.h pac.h nvmctrl.h ac.h trng.h tcc1.h oscctrl.h tc3.h ccl.h sercom2.h gclk.h adc.h rtc.h tcc2.h tc1.h supc.h evsys.h sercom3.h eic.h pm.h sercom0.h tal.h usb.h dac.h aes.h sercom4.h port.h sercom1.h rstc.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../utils/cmsis/saml21/include_b/component/: wdt.h adc.h rstc.h supc.h pac.h opamp.h rtc.h mtb.h tc.h port.h evsys.h aes.h trng.h mclk.h dac.h ccl.h dmac.h sercom.h osc32kctrl.h dsu.h pm.h nvmctrl.h oscctrl.h tcc.h tal.h eic.h ac.h usb.h gclk.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../utils/cmsis/saml21/include_b/pio/: saml21e17b.h saml21j16b.h saml21e16b.h saml21e18b.h saml21g16b.h saml21j17b.h saml21g18b.h saml21g17b.h saml21e15b.h saml21j18b.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrecursion.h mrepeat.h preprocessor.h stringz.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/applications/sleepwalking_adc
    ../../: vcc_monitor.c
  group sam0/applications/sleepwalking_adc/saml21_xplained_pro_b
    ../: conf_rtc.h conf_board.h conf_clocks.h
  group sam0/applications/sleepwalking_adc/saml21_xplained_pro_b/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
