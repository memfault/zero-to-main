# IAR project sleepwalking_adc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; SYSTICK_MODE; BOARD=SAML22_XPLAINED_PRO_B; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; __SAML22N18A__
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../drivers/adc; ../..; ../../../../drivers/rtc/rtc_sam_l_c; ../../../../utils/preprocessor; ../../../../utils/cmsis/saml22/include; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/port; ../../../../boards; ..; ../../../../drivers/events/events_sam_l_c; ../../../../drivers/rtc; ../../../../utils/cmsis/saml22/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ../../../../boards/saml22_xplained_pro_b; ../../../../drivers/system/interrupt/system_interrupt_saml22; ../../../../../common/utils; ../../../../../common2/services/delay/sam0; ../../../../drivers/system/clock/clock_saml22; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/adc/adc_sam_l_c; ../../../../drivers/events; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepwalking_adc_flash.bin
  ILINK.IlinkOutputFile: sleepwalking_adc_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../utils/cmsis/saml22/include/: saml22n17a.h saml22n16a.h saml22j18a.h saml22g17a.h saml22.h saml22j17a.h saml22g18a.h saml22j16a.h saml22n18a.h saml22g16a.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../utils/cmsis/saml22/include/component/: mclk.h ac.h aes.h wdt.h evsys.h gclk.h tc.h supc.h rtc.h pac.h adc.h mtb.h rstc.h slcd.h eic.h ccl.h usb.h trng.h dsu.h pm.h tcc.h tal.h dmac.h port.h nvmctrl.h sercom.h oscctrl.h freqm.h osc32kctrl.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../utils/cmsis/saml22/include/instance/: rstc.h pac.h sercom3.h nvmctrl.h trng.h sercom5.h mclk.h wdt.h usb.h gclk.h port.h eic.h tal.h tc1.h dmac.h evsys.h tc2.h pm.h ac.h tc0.h supc.h mtb.h adc.h slcd.h sercom0.h oscctrl.h freqm.h tc3.h ccl.h aes.h sercom2.h sercom4.h rtc.h dsu.h osc32kctrl.h sercom1.h tcc0.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../utils/cmsis/saml22/include/pio/: saml22j18a.h saml22g18a.h saml22n16a.h saml22g16a.h saml22n17a.h saml22n18a.h saml22j16a.h saml22g17a.h saml22j17a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group sam0/drivers/adc
    ../../../../drivers/adc/: adc_callback.h adc.h
  group sam0/drivers/adc/adc_sam_l_c
    ../../../../drivers/adc/adc_sam_l_c/: adc.c adc_callback.c adc_feature.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../drivers/rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../drivers/rtc/rtc_sam_l_c/: rtc_count.c
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events.h events_hooks.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../drivers/events/events_sam_l_c/: events.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../drivers/system/clock/clock_saml22/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/applications/sleepwalking_adc
    ../../: vcc_monitor.c
  group sam0/applications/sleepwalking_adc/saml22_xplained_pro_b
    ../: conf_board.h conf_rtc.h conf_clocks.h
  group sam0/applications/sleepwalking_adc/saml22_xplained_pro_b/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
