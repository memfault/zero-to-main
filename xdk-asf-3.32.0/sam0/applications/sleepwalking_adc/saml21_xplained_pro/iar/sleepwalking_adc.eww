<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sleepwalking_adc_flash.ewp</path>
	</project>
</workspace>
