# IAR project tamper_detection_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO; TCC_ASYNC=true; ARM_MATH_CM0PLUS=true; RTC_CALENDAR_ASYNC=true; USART_CALLBACK_MODE=false; __SAML22N18A__; CYCLE_MODE
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../drivers/rtc/rtc_sam_l_c; ../../../../utils/preprocessor; ../../../../utils/cmsis/saml22/include; ../../../../drivers/dma; ../../../../../common2/services/delay; ../../../../services/eeprom/emulator/rwwee_array; ../../../../utils; ../../../../drivers/nvm; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../../../../drivers/rtc; ../../../../../common/services/sleepmgr; ../../../../utils/cmsis/saml22/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ..; ../../../../drivers/system/interrupt/system_interrupt_saml22; ../../../../../common/utils; ../..; ../../../../../common2/services/delay/sam0; ../../../../drivers/slcd; ../../../../drivers/tcc; ../../../../drivers/system/clock/clock_saml22; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ../../../../boards/saml22_xplained_pro; ../../../../utils/stdio/stdio_serial; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tamper_detection_example_flash.bin
  ILINK.IlinkOutputFile: tamper_detection_example_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../common/services/sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml22/source
    ../../../../utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../utils/cmsis/saml22/include/: saml22n17a.h saml22n16a.h saml22g17a.h saml22.h saml22j17a.h saml22g18a.h saml22j16a.h saml22j18a.h saml22n18a.h saml22g16a.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../utils/cmsis/saml22/include/component/: mclk.h ac.h aes.h sercom.h wdt.h evsys.h gclk.h tc.h supc.h pac.h adc.h mtb.h rstc.h slcd.h eic.h ccl.h usb.h trng.h dsu.h pm.h rtc.h tcc.h tal.h dmac.h port.h nvmctrl.h oscctrl.h freqm.h osc32kctrl.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../utils/cmsis/saml22/include/instance/: rstc.h pac.h sercom3.h nvmctrl.h sercom5.h mclk.h wdt.h usb.h gclk.h port.h tal.h tc1.h dmac.h evsys.h tc2.h pm.h ac.h trng.h tc0.h supc.h mtb.h adc.h slcd.h sercom0.h freqm.h tc3.h ccl.h aes.h eic.h sercom2.h sercom4.h rtc.h dsu.h oscctrl.h osc32kctrl.h sercom1.h tcc0.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../utils/cmsis/saml22/include/pio/: saml22j18a.h saml22g18a.h saml22n16a.h saml22g16a.h saml22n17a.h saml22n18a.h saml22j16a.h saml22g17a.h saml22j17a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../drivers/system/clock/clock_saml22/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/drivers/rtc
    ../../../../drivers/rtc/: rtc_calendar_interrupt.h rtc_calendar.h rtc_tamper.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../drivers/rtc/rtc_sam_l_c/: rtc_calendar_interrupt.c rtc_calendar.c
  group sam0/drivers/dma
    ../../../../drivers/dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../drivers/dma/quick_start/: qs_dma_basic.h
  group sam0/drivers/tcc
    ../../../../drivers/tcc/: tcc.c tcc_callback.c tcc.h tcc_callback.h
  group sam0/drivers/tcc/quick_start_callback
    ../../../../drivers/tcc/quick_start_callback/: qs_tcc_callback.h
  group sam0/drivers/tcc/quick_start_timer
    ../../../../drivers/tcc/quick_start_timer/: qs_tcc_timer.h
  group sam0/drivers/tcc/quick_start_faultx
    ../../../../drivers/tcc/quick_start_faultx/: qs_tcc_faultx.h
  group sam0/drivers/tcc/quick_start_dma
    ../../../../drivers/tcc/quick_start_dma/: qs_tcc_dma.h
  group sam0/drivers/tcc/quick_start
    ../../../../drivers/tcc/quick_start/: qs_tcc_basic.h
  group sam0/drivers/tcc/quick_start_buffering
    ../../../../drivers/tcc/quick_start_buffering/: qs_tcc_buffering.h
  group sam0/drivers/tcc/quick_start_faultn
    ../../../../drivers/tcc/quick_start_faultn/: qs_tcc_faultn.h
  group sam0/drivers/slcd
    ../../../../drivers/slcd/: slcd.c slcd.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../../services/eeprom/emulator/rwwee_array/: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../../../services/eeprom/emulator/rwwee_array/quick_start/: qs_emulator_basic.h
  group sam0/applications/tamper_detection_example
    ../../: main.c
  group sam0/applications/tamper_detection_example/saml22_xplained_pro
    ../: conf_rtc.h conf_board.h conf_rwwee.h conf_dma.h conf_sleepmgr.h conf_slcd.h conf_example.h conf_clocks.h
  group sam0/applications/tamper_detection_example/saml22_xplained_pro/iar
    ./: asf.h
  group sam0/boards/saml22_xplained_pro
    ../../../../boards/saml22_xplained_pro/: board_init.c saml22_xplained_pro.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
