<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\tamper_detection_example_flash.ewp</path>
	</project>
</workspace>
