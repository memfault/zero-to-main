# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CYCLE_MODE; BOARD=SAMD21_XPLAINED_PRO; RTC_CALENDAR_ASYNC=false; SD_MMC_ENABLE; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMD21J18A__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r; ../../../../../../../sam0/drivers/rtc; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../../../services/delay/sam0; ..; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../..; ../../..; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../common/services/storage/ctrl_access; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/memory/sd_mmc
    ../../../: sd_mmc_mem.c sd_mmc_spi.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h sd_mmc_mem.h
  group common2/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common2/components/memory/sd_mmc/example2/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_sleepmgr.h conf_example.h conf_spi.h conf_clocks.h conf_sd_mmc.h
  group common2/components/memory/sd_mmc/example2/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: cycle_counter.c cycle_counter.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h ffconf.h integer.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../sam0/utils/cmsis/samd21/include/: samd21.h samd21g18a.h samd21j18a.h samd21j15a.h samd21g18au.h samd21g16b.h samd21g16l.h samd21e16a.h samd21j16b.h samd21e18a.h samd21j15b.h samd21e16l.h samd21e16b.h samd21e17a.h samd21e15b.h samd21e15l.h samd21g15a.h samd21j17a.h samd21e16bu.h samd21g17a.h samd21e15a.h samd21g15b.h samd21j16a.h samd21g15l.h samd21e15bu.h samd21g17au.h samd21g16a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../sam0/utils/cmsis/samd21/include/component/: mtb.h tcc_lighting.h tcc.h i2s.h nvmctrl.h evsys.h adc.h ac.h rtc.h port.h pm.h pac.h gclk.h tc.h usb.h sysctrl.h dac.h eic.h dmac.h hmatrixb.h dsu.h sercom.h wdt.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../sam0/utils/cmsis/samd21/include/instance/: nvmctrl.h i2s.h pac1.h mtb.h sercom0.h sysctrl.h ac1.h tcc1.h adc.h eic.h pm.h tc6.h tc4.h dac.h pac2.h wdt.h sercom4.h sercom2.h pac0.h sercom1.h sbmatrix.h tc7.h tcc0.h tc5.h sercom5.h dsu.h tcc2.h sercom3.h evsys.h rtc.h port.h ac.h dmac.h usb.h gclk.h tc3.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g18au.h samd21e15bu.h samd21j17a.h samd21e17a.h samd21e15b.h samd21g17a.h samd21e16b.h samd21j15b.h samd21e16l.h samd21j16a.h samd21g16b.h samd21g18a.h samd21j18a.h samd21j16b.h samd21g16a.h samd21e18a.h samd21j15a.h samd21g15a.h samd21e15l.h samd21e16bu.h samd21g15l.h samd21g16l.h samd21g17au.h samd21e16a.h samd21e15a.h samd21g15b.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_calendar.h
  group sam0/drivers/rtc/rtc_sam_d_r
    ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r/: rtc_calendar.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/services/storage/ctrl_access
    ../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
