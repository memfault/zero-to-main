<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_spinctrl_flash.ewp</path>
	</project>
</workspace>
