# IAR project example_spinctrl_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; ARM_MATH_CM0PLUS=true; __SAML21J18B__; SPI_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../..; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/boards/saml21_xplained_pro_b; ../../../../delay; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/utils/cmsis/saml21/include_b; ../../../../../components/display/ssd1306; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../delay/sam0; ..; ../../../../../../sam0/drivers/system/clock/clock_saml21; ../..; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_spinctrl_flash.bin
  ILINK.IlinkOutputFile: example_spinctrl_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../../../components/display/ssd1306/: ssd1306.c ssd1306.h
  group common2/services/gfx_mono
    ../../../: gfx_mono_ug_2832hsweg04.c gfx_mono_text.c sysfont.c gfx_mono_spinctrl.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_text.h sysfont.h gfx_mono.h gfx_mono_generic.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_spinctrl.h
  group common2/services/gfx_mono/example_spinctrl
    ../../: example_spinctrl.c
  group common2/services/gfx_mono/example_spinctrl/saml21_xplained_pro_b
    ../: conf_spinctrl.h conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h conf_sysfont.h
  group common2/services/gfx_mono/example_spinctrl/saml21_xplained_pro_b/iar
    ./: asf.h
  group common2/services/delay
    ../../../../delay/: delay.h
  group common2/services/delay/sam0
    ../../../../delay/sam0/: systick_counter.c systick_counter.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e17b.h saml21g18b.h saml21.h saml21j18b.h saml21e15b.h saml21e18b.h saml21e16b.h saml21j16b.h saml21g16b.h saml21g17b.h saml21j17b.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../sam0/utils/cmsis/saml21/include_b/component/: tc.h mclk.h ccl.h dac.h supc.h oscctrl.h ac.h evsys.h osc32kctrl.h tal.h tcc.h port.h eic.h aes.h pac.h usb.h pm.h dmac.h rstc.h wdt.h opamp.h gclk.h nvmctrl.h sercom.h rtc.h dsu.h trng.h mtb.h adc.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: tc3.h supc.h sercom3.h wdt.h tcc1.h pm.h ac.h rtc.h usb.h dac.h tc4.h gclk.h aes.h tcc2.h trng.h dmac.h rstc.h oscctrl.h tcc0.h pac.h eic.h mclk.h evsys.h sercom4.h nvmctrl.h adc.h mtb.h tc1.h sercom0.h tc0.h sercom2.h tal.h port.h sercom1.h sercom5.h tc2.h dsu.h ccl.h opamp.h osc32kctrl.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21g18b.h saml21e17b.h saml21g17b.h saml21e15b.h saml21e16b.h saml21j18b.h saml21g16b.h saml21e18b.h saml21j16b.h saml21j17b.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
