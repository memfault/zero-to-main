# IAR project example_spinctrl_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/utils/cmsis/samr30/source; ../../..; ../../../../../../sam0/utils/preprocessor; ../../../../../components/display/ssd1306; ../../../../delay; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ..; ../../../../../../sam0/drivers/system/reset; ../../../../../../common/utils; ../../../../../../sam0/boards/samr30_xplained_pro; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../../sam0/utils/cmsis/samr30/include; ../../../../delay/sam0; ../..; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/drivers/system/clock/clock_samr30; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_spinctrl_flash.bin
  ILINK.IlinkOutputFile: example_spinctrl_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../../../components/display/ssd1306/: ssd1306.c ssd1306.h
  group common2/services/gfx_mono
    ../../../: gfx_mono_ug_2832hsweg04.c gfx_mono_text.c sysfont.c gfx_mono_spinctrl.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_text.h sysfont.h gfx_mono_generic.h gfx_mono_framebuffer.h gfx_mono.h gfx_mono_ug_2832hsweg04.h gfx_mono_spinctrl.h
  group common2/services/gfx_mono/example_spinctrl
    ../../: example_spinctrl.c
  group common2/services/gfx_mono/example_spinctrl/samr30_xplained_pro
    ../: conf_spinctrl.h conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h conf_sysfont.h
  group common2/services/gfx_mono/example_spinctrl/samr30_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../delay/: delay.h
  group common2/services/delay/sam0
    ../../../../delay/sam0/: systick_counter.c systick_counter.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../sam0/utils/cmsis/samr30/include/: samr30.h samr30e18a.h samr30g18a.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../sam0/utils/cmsis/samr30/include/component/: tcc.h sercom.h pac.h ccl.h mclk.h mtb.h ac.h adc.h tc.h rfctrl.h pm.h rtc.h wdt.h supc.h dmac.h rstc.h usb.h gclk.h eic.h evsys.h tal.h oscctrl.h dsu.h port.h osc32kctrl.h nvmctrl.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../sam0/utils/cmsis/samr30/include/instance/: sercom0.h dsu.h tc4.h nvmctrl.h rstc.h tc0.h sercom4.h rtc.h mtb.h mclk.h ccl.h port.h tal.h dmac.h gclk.h eic.h sercom3.h tcc2.h pm.h ac.h tcc0.h sercom2.h adc.h usb.h tc1.h tcc1.h osc32kctrl.h sercom1.h rfctrl.h wdt.h evsys.h oscctrl.h pac.h sercom5.h supc.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30e18a.h samr30g18a.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h mrecursion.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../sam0/drivers/system/clock/clock_samr30/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
