<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\example_sysfont_flash.ewp</path>
	</project>
</workspace>
