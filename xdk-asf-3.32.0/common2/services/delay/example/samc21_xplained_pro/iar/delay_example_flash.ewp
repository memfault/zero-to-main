# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Atmel ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMC21_XPLAINED_PRO; SYSTICK_MODE; __SAMC21J18A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/utils/cmsis/samc21/include; ../../../../../../sam0/drivers/system/power; ..; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/cmsis/samc21/source; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/port; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samc20_c21; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_c; ../../../sam0; ../../../../../../sam0/drivers/system/clock/clock_samc20_c21; ../../../../../../sam0/drivers/system/reset/reset_sam_c; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/boards/samc21_xplained_pro; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samc21/iar/samc21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samc20_c21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samc20_c21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samc20_c21
    ../../../../../../sam0/drivers/system/clock/clock_samc20_c21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_c
    ../../../../../../sam0/drivers/system/power/power_sam_c/: power.h
  group sam0/drivers/system/reset/reset_sam_c
    ../../../../../../sam0/drivers/system/reset/reset_sam_c/: reset.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samc21_xplained_pro
    ../../../../../../sam0/boards/samc21_xplained_pro/: board_init.c samc21_xplained_pro.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samc21/source
    ../../../../../../sam0/utils/cmsis/samc21/source/: system_samc21.c system_samc21.h
  group sam0/utils/cmsis/samc21/source/iar
    ../../../../../../sam0/utils/cmsis/samc21/source/iar/: startup_samc21.c
  group sam0/utils/cmsis/samc21/include
    ../../../../../../sam0/utils/cmsis/samc21/include/: samc21j16a.h samc21g17a.h samc21j18a.h samc21e17a.h samc21j17a.h samc21j15a.h samc21e16a.h samc21.h samc21e18a.h samc21g16a.h samc21e15a.h samc21g18a.h samc21g15a.h
  group sam0/utils/cmsis/samc21/include/component
    ../../../../../../sam0/utils/cmsis/samc21/include/component/: hmatrixb.h can.h freqm.h osc32kctrl.h nvmctrl.h mtb.h port.h oscctrl.h eic.h dac.h rtc.h wdt.h divas.h pac.h sercom.h supc.h rstc.h dsu.h pm.h sdadc.h tsens.h tal.h tcc.h evsys.h dmac.h tc.h mclk.h ccl.h ac.h gclk.h adc.h
  group sam0/utils/cmsis/samc21/include/instance
    ../../../../../../sam0/utils/cmsis/samc21/include/instance/: can0.h sercom1.h wdt.h pac.h ccl.h tc1.h hmatrixhs.h oscctrl.h sercom5.h gclk.h tcc0.h port.h tsens.h freqm.h rtc.h mclk.h tcc1.h mtb.h tal.h evsys.h sercom2.h osc32kctrl.h dsu.h eic.h adc1.h pm.h sdadc.h ac.h tcc2.h dac.h nvmctrl.h tc4.h tc0.h sercom3.h divas.h tc2.h can1.h sercom0.h adc0.h supc.h rstc.h tc3.h sercom4.h dmac.h
  group sam0/utils/cmsis/samc21/include/pio
    ../../../../../../sam0/utils/cmsis/samc21/include/pio/: samc21j18a.h samc21j15a.h samc21g15a.h samc21e18a.h samc21g16a.h samc21e16a.h samc21e15a.h samc21e17a.h samc21g17a.h samc21j16a.h samc21g18a.h samc21j17a.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samc21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samc21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
