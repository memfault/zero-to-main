# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/boards/saml21_xplained_pro; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ..; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../sam0; ../../../../../../sam0/utils/cmsis/saml21/include; ../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/saml21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../sam0/utils/cmsis/saml21/include/: saml21.h saml21e18a.h saml21g18a.h saml21j18a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../sam0/utils/cmsis/saml21/include/component/: pm_100.h pac_100.h dmac.h ccl.h trng.h supc_100.h mclk_100.h dac.h dsu.h eic_100.h gclk_100.h aes.h rtc_100.h tcc_200.h tc_100.h tal.h nvmctrl_301.h opamp.h sercom.h wdt.h usb.h rstc_100.h evsys.h port.h oscctrl.h osc32kctrl.h adc_100.h mtb.h ac.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../sam0/utils/cmsis/saml21/include/instance/: oscctrl.h rtc_100.h sercom5.h supc_100.h sercom2.h sercom1.h mclk_100.h mtb.h ccl.h dsu.h tcc1_200.h tc2_100.h pac_100.h sercom4.h tc1_100.h ac.h sercom0.h trng.h opamp.h tcc2_200.h aes.h rstc_100.h osc32kctrl.h pm_100.h tc3_100.h usb.h dmac.h eic_100.h evsys.h gclk_100.h sercom3.h tcc0_200.h nvmctrl_301.h adc_100.h port.h wdt.h dac.h tc0_100.h tal.h tc4_100.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21g18a.h saml21j18a.h saml21e18a.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
