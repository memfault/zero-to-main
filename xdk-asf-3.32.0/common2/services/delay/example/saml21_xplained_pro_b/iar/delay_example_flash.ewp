# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAML21_XPLAINED_PRO; __SAML21J18B__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/boards/saml21_xplained_pro_b; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/utils/cmsis/saml21/include_b; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/utils/header_files; ..; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../sam0; ../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/saml21_xplained_pro_b
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/saml21_xplained_pro_b/iar
    ./: asf.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e17b.h saml21g18b.h saml21.h saml21j18b.h saml21e15b.h saml21e18b.h saml21e16b.h saml21j16b.h saml21g16b.h saml21g17b.h saml21j17b.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../sam0/utils/cmsis/saml21/include_b/component/: tc.h mclk.h ccl.h dac.h supc.h oscctrl.h ac.h evsys.h osc32kctrl.h tal.h tcc.h port.h eic.h aes.h pac.h usb.h dmac.h rstc.h wdt.h pm.h opamp.h gclk.h nvmctrl.h sercom.h rtc.h dsu.h trng.h mtb.h adc.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: tc3.h supc.h sercom3.h wdt.h tcc1.h pm.h ac.h rtc.h usb.h dac.h tc4.h gclk.h aes.h tcc2.h trng.h dmac.h rstc.h oscctrl.h tcc0.h pac.h eic.h mclk.h evsys.h sercom4.h nvmctrl.h adc.h mtb.h tc1.h sercom0.h tc0.h sercom2.h tal.h port.h sercom1.h sercom5.h tc2.h dsu.h ccl.h opamp.h osc32kctrl.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21g18b.h saml21e17b.h saml21g17b.h saml21e15b.h saml21e16b.h saml21j18b.h saml21g16b.h saml21j17b.h saml21e18b.h saml21j16b.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
