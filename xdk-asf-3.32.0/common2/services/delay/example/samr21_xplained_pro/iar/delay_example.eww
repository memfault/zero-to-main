<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\delay_example_flash.ewp</path>
	</project>
</workspace>
