# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/utils/cmsis/samr21/source; ../../..; ../../../../../../sam0/utils; ..; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../sam0; ../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../sam0/utils/cmsis/samr21/include; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../sam0/utils/cmsis/samr21/include/: samr21g18a.h samr21e17a.h samr21e16a.h samr21e18a.h samr21g17a.h samr21e19a.h samr21g16a.h samr21.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../sam0/utils/cmsis/samr21/include/component/: dmac.h sercom.h nvmctrl.h pac.h dsu.h ac.h hmatrixb.h rfctrl.h rtc.h adc.h port.h tc.h sysctrl.h evsys.h mtb.h wdt.h eic.h gclk.h usb.h pm.h tcc.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../sam0/utils/cmsis/samr21/include/instance/: mtb.h usb.h tc3.h gclk.h sercom1.h tc5.h sercom3.h rfctrl.h sercom4.h sercom0.h port.h tc4.h sercom5.h sercom2.h sbmatrix.h rtc.h tcc0.h pm.h pac0.h ac.h sysctrl.h adc.h wdt.h nvmctrl.h dsu.h dmac.h pac2.h eic.h tcc1.h evsys.h pac1.h tcc2.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21e18a.h samr21e16a.h samr21e19a.h samr21g17a.h samr21g16a.h samr21g18a.h samr21e17a.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samr21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
