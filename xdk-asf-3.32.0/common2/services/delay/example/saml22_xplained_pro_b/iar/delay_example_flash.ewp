# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAML22_XPLAINED_PRO_B; __SAML22N18A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/utils/cmsis/saml22/include; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../sam0/boards/saml22_xplained_pro_b; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22; ..; ../../../../../../sam0/utils/cmsis/saml22/source; ../../../sam0; ../../../../../../sam0/drivers/system/clock/clock_saml22; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../sam0/utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../sam0/utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../sam0/utils/cmsis/saml22/include/: saml22g17a.h saml22j18a.h saml22j17a.h saml22n17a.h saml22j16a.h saml22n18a.h saml22.h saml22g18a.h saml22n16a.h saml22g16a.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../sam0/utils/cmsis/saml22/include/pio/: saml22j17a.h saml22g16a.h saml22n16a.h saml22n18a.h saml22j16a.h saml22g17a.h saml22j18a.h saml22n17a.h saml22g18a.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../sam0/utils/cmsis/saml22/include/instance/: adc.h rtc.h nvmctrl.h usb.h evsys.h sercom5.h aes.h tcc0.h sercom1.h pac.h port.h tal.h sercom3.h mtb.h oscctrl.h tc0.h slcd.h tc2.h dmac.h wdt.h pm.h ac.h sercom2.h tc3.h osc32kctrl.h mclk.h gclk.h supc.h eic.h ccl.h freqm.h rstc.h trng.h tc1.h sercom0.h dsu.h sercom4.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../sam0/utils/cmsis/saml22/include/component/: port.h aes.h adc.h eic.h sercom.h freqm.h rstc.h ccl.h slcd.h pm.h rtc.h ac.h osc32kctrl.h pac.h gclk.h mtb.h wdt.h tal.h tcc.h supc.h nvmctrl.h tc.h oscctrl.h evsys.h trng.h mclk.h dmac.h dsu.h usb.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: tpaste.h preprocessor.h mrecursion.h stringz.h mrepeat.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../sam0/drivers/system/clock/clock_saml22/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../sam0/boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/saml22_xplained_pro_b
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/saml22_xplained_pro_b/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
