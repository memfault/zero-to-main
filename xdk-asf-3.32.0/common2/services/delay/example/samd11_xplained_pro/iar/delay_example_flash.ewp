# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/drivers/system/clock/clock_samd09_d10_d11; ../../../../../../sam0/utils; ../../../../../../sam0/boards/samd11_xplained_pro; ../../../../../../sam0/drivers/port; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../../../common/utils; ../../../../../../sam0/utils/cmsis/samd11/source; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../../../sam0/utils/cmsis/samd11/include; ../../../sam0; ..; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd09_d10_d11
    ../../../../../../sam0/drivers/system/clock/clock_samd09_d10_d11/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../sam0/utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../sam0/utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../sam0/utils/cmsis/samd11/include/: samd11d14am.h samd11d14as.h samd11c14a.h samd11.h samd11d14au.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../sam0/utils/cmsis/samd11/include/component/: pm.h ac.h adc.h sercom.h mtb.h nvmctrl.h dac.h rtc.h dsu.h usb.h dmac.h hmatrixb.h wdt.h tc.h evsys.h port.h sysctrl.h eic.h pac.h gclk.h tcc.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../sam0/utils/cmsis/samd11/include/instance/: evsys.h eic.h gclk.h mtb.h nvmctrl.h dmac.h usb.h pac1.h tc2.h dac.h sercom2.h sercom1.h ac.h sercom0.h pac0.h tc1.h sysctrl.h dsu.h tcc0.h adc.h wdt.h pm.h pac2.h port.h sbmatrix.h rtc.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../sam0/utils/cmsis/samd11/include/pio/: samd11d14as.h samd11d14au.h samd11d14am.h samd11c14a.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../sam0/boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samd11_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
